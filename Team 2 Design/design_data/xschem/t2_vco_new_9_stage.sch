v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 770 2050 1030 2050 {lab=VGND}
N 580 1900 690 1900 {lab=vctl}
N 730 1900 770 1900 {lab=VGND}
N 770 1900 770 2050 {lab=VGND}
N 730 1930 730 2050 {lab=VGND}
N 1050 1900 1070 1900 {lab=VGND}
N 1070 1900 1070 2050 {lab=VGND}
N 1030 1930 1030 2050 {lab=VGND}
N 1370 1900 1390 1900 {lab=VGND}
N 1390 1900 1390 2050 {lab=VGND}
N 1350 1930 1350 2050 {lab=VGND}
N 1690 1900 1710 1900 {lab=VGND}
N 1710 1900 1710 2050 {lab=VGND}
N 1670 1930 1670 2050 {lab=VGND}
N 770 1290 1030 1290 {lab=VPWR}
N 1090 1290 1350 1290 {lab=VPWR}
N 1410 1290 1670 1290 {lab=VPWR}
N 730 1510 730 1870 {lab=mirror_pg}
N 630 1440 690 1440 {lab=mirror_pg}
N 630 1440 630 1510 {lab=mirror_pg}
N 630 1510 730 1510 {lab=mirror_pg}
N 730 1470 730 1510 {lab=mirror_pg}
N 730 1440 770 1440 {lab=VPWR}
N 730 1290 730 1410 {lab=VPWR}
N 1050 1440 1090 1440 {lab=VPWR}
N 1030 1290 1030 1410 {lab=VPWR}
N 1370 1440 1410 1440 {lab=VPWR}
N 1350 1290 1350 1410 {lab=VPWR}
N 1690 1440 1730 1440 {lab=VPWR}
N 1670 1290 1670 1410 {lab=VPWR}
N 1070 2050 1350 2050 {lab=VGND}
N 1390 2050 1670 2050 {lab=VGND}
N 4640 1850 4640 2050 {lab=VGND}
N 1710 2050 2050 2050 {lab=VGND}
N 5000 1850 5000 2050 {lab=VGND}
N 4780 2050 5000 2050 {lab=VGND}
N 2070 1900 2090 1900 {lab=VGND}
N 2090 1900 2090 2050 {lab=VGND}
N 2050 1930 2050 2050 {lab=VGND}
N 2390 1900 2410 1900 {lab=VGND}
N 2370 1930 2370 2050 {lab=VGND}
N 2070 1440 2110 1440 {lab=VPWR}
N 2050 1290 2050 1410 {lab=VPWR}
N 2390 1440 2430 1440 {lab=VPWR}
N 2370 1290 2370 1410 {lab=VPWR}
N 2090 2050 2370 2050 {lab=VGND}
N 4760 2050 4780 2050 {lab=VGND}
N 2110 1290 2370 1290 {lab=VPWR}
N 1730 1290 2050 1290 {lab=VPWR}
N 5000 1650 5000 1790 {lab=Vout}
N 610 1440 630 1440 {lab=mirror_pg}
N 970 1440 990 1440 {lab=mirror_pg}
N 1290 1440 1310 1440 {lab=mirror_pg}
N 1610 1440 1630 1440 {lab=mirror_pg}
N 1990 1440 2010 1440 {lab=mirror_pg}
N 770 1290 770 1440 {lab=VPWR}
N 730 1290 770 1290 {lab=VPWR}
N 1090 1290 1090 1440 {lab=VPWR}
N 1030 1290 1090 1290 {lab=VPWR}
N 2430 1290 2430 1440 {lab=VPWR}
N 2370 1290 2430 1290 {lab=VPWR}
N 2110 1290 2110 1440 {lab=VPWR}
N 2050 1290 2110 1290 {lab=VPWR}
N 1730 1290 1730 1440 {lab=VPWR}
N 1670 1290 1730 1290 {lab=VPWR}
N 1410 1290 1410 1440 {lab=VPWR}
N 1350 1290 1410 1290 {lab=VPWR}
N 2310 1440 2330 1440 {lab=mirror_pg}
N 970 1900 990 1900 {lab=vctl}
N 1290 1900 1310 1900 {lab=vctl}
N 1610 1900 1630 1900 {lab=vctl}
N 1990 1900 2010 1900 {lab=vctl}
N 2310 1900 2330 1900 {lab=vctl}
N 730 2050 770 2050 {lab=VGND}
N 1030 2050 1070 2050 {lab=VGND}
N 1350 2050 1390 2050 {lab=VGND}
N 1670 2050 1710 2050 {lab=VGND}
N 2050 2050 2090 2050 {lab=VGND}
N 2410 1900 2410 2050 {lab=VGND}
N 2370 2050 2410 2050 {lab=VGND}
N 580 1900 580 2000 {lab=vctl}
N 1990 2000 2310 2000 {lab=vctl}
N 2310 1900 2310 2000 {lab=vctl}
N 1990 1900 1990 2000 {lab=vctl}
N 1610 1900 1610 2000 {lab=vctl}
N 1610 2000 1990 2000 {lab=vctl}
N 1290 2000 1610 2000 {lab=vctl}
N 1290 1900 1290 2000 {lab=vctl}
N 970 2000 1290 2000 {lab=vctl}
N 970 1900 970 2000 {lab=vctl}
N 580 2000 970 2000 {lab=vctl}
N 1030 1470 1030 1580 {lab=#net1}
N 1350 1470 1350 1580 {lab=#net2}
N 1370 1440 1370 1580 {lab=VPWR}
N 1350 1440 1370 1440 {lab=VPWR}
N 1050 1440 1050 1580 {lab=VPWR}
N 1030 1440 1050 1440 {lab=VPWR}
N 4640 1650 4670 1650 {lab=feedback}
N 2390 1440 2390 1580 {lab=VPWR}
N 2370 1440 2390 1440 {lab=VPWR}
N 1670 1470 1670 1580 {lab=#net3}
N 1690 1440 1690 1580 {lab=VPWR}
N 1670 1440 1690 1440 {lab=VPWR}
N 850 1650 940 1650 {lab=feedback}
N 1150 1650 1270 1650 {lab=#net4}
N 1470 1650 1580 1650 {lab=#net5}
N 1790 1650 1960 1650 {lab=#net6}
N 1670 1720 1670 1870 {lab=#net7}
N 1690 1720 1690 1900 {lab=VGND}
N 1670 1900 1690 1900 {lab=VGND}
N 1350 1720 1350 1870 {lab=#net8}
N 1370 1720 1370 1900 {lab=VGND}
N 1350 1900 1370 1900 {lab=VGND}
N 1030 1720 1030 1870 {lab=#net9}
N 1050 1720 1050 1900 {lab=VGND}
N 1030 1900 1050 1900 {lab=VGND}
N 2050 1720 2050 1870 {lab=#net10}
N 2070 1720 2070 1900 {lab=VGND}
N 2050 1900 2070 1900 {lab=VGND}
N 2370 1720 2370 1870 {lab=#net11}
N 2390 1720 2390 1900 {lab=VGND}
N 2370 1900 2390 1900 {lab=VGND}
N 4780 1720 4780 2050 {lab=VGND}
N 4760 1720 4760 2050 {lab=VGND}
N 4640 2050 4760 2050 {lab=VGND}
N 4760 1290 4760 1580 {lab=VPWR}
N 4780 1290 4780 1580 {lab=VPWR}
N 4760 1290 4780 1290 {lab=VPWR}
N 2370 1470 2370 1580 {lab=#net12}
N 2070 1440 2070 1580 {lab=VPWR}
N 2050 1440 2070 1440 {lab=VPWR}
N 2050 1470 2050 1580 {lab=#net13}
N 2170 1650 2280 1650 {lab=#net14}
N 4880 1650 5000 1650 {lab=Vout}
N 4640 1650 4640 1790 {lab=feedback}
N 2760 1900 2780 1900 {lab=VGND}
N 2780 1900 2780 2050 {lab=VGND}
N 2740 1930 2740 2050 {lab=VGND}
N 3080 1900 3100 1900 {lab=VGND}
N 3100 1900 3100 2050 {lab=VGND}
N 3060 1930 3060 2050 {lab=VGND}
N 2800 1290 3060 1290 {lab=VPWR}
N 2760 1440 2800 1440 {lab=VPWR}
N 2740 1290 2740 1410 {lab=VPWR}
N 3080 1440 3120 1440 {lab=VPWR}
N 3060 1290 3060 1410 {lab=VPWR}
N 2780 2050 3060 2050 {lab=VGND}
N 4520 1290 4760 1290 {lab=VPWR}
N 3100 2050 3440 2050 {lab=VGND}
N 3460 1900 3480 1900 {lab=VGND}
N 3480 1900 3480 2050 {lab=VGND}
N 3440 1930 3440 2050 {lab=VGND}
N 3780 1900 3800 1900 {lab=VGND}
N 3760 1930 3760 2050 {lab=VGND}
N 3460 1440 3500 1440 {lab=VPWR}
N 3440 1290 3440 1410 {lab=VPWR}
N 3780 1440 3820 1440 {lab=VPWR}
N 3760 1290 3760 1410 {lab=VPWR}
N 3480 2050 3760 2050 {lab=VGND}
N 3500 1290 3760 1290 {lab=VPWR}
N 3120 1290 3440 1290 {lab=VPWR}
N 2680 1440 2700 1440 {lab=mirror_pg}
N 3000 1440 3020 1440 {lab=mirror_pg}
N 3380 1440 3400 1440 {lab=mirror_pg}
N 3820 1290 3820 1440 {lab=VPWR}
N 3760 1290 3820 1290 {lab=VPWR}
N 3500 1290 3500 1440 {lab=VPWR}
N 3440 1290 3500 1290 {lab=VPWR}
N 3120 1290 3120 1440 {lab=VPWR}
N 3060 1290 3120 1290 {lab=VPWR}
N 2800 1290 2800 1440 {lab=VPWR}
N 2740 1290 2800 1290 {lab=VPWR}
N 3700 1440 3720 1440 {lab=mirror_pg}
N 2680 1900 2700 1900 {lab=vctl}
N 3000 1900 3020 1900 {lab=vctl}
N 3380 1900 3400 1900 {lab=vctl}
N 3700 1900 3720 1900 {lab=vctl}
N 2740 2050 2780 2050 {lab=VGND}
N 3060 2050 3100 2050 {lab=VGND}
N 3440 2050 3480 2050 {lab=VGND}
N 3800 1900 3800 2050 {lab=VGND}
N 3760 2050 3800 2050 {lab=VGND}
N 3380 2000 3700 2000 {lab=vctl}
N 3700 1900 3700 2000 {lab=vctl}
N 3380 1900 3380 2000 {lab=vctl}
N 3000 1900 3000 2000 {lab=vctl}
N 3000 2000 3380 2000 {lab=vctl}
N 2680 2000 3000 2000 {lab=vctl}
N 2680 1900 2680 2000 {lab=vctl}
N 2740 1470 2740 1580 {lab=#net15}
N 2760 1440 2760 1580 {lab=VPWR}
N 2740 1440 2760 1440 {lab=VPWR}
N 4500 2050 4640 2050 {lab=VGND}
N 3780 1440 3780 1580 {lab=VPWR}
N 3760 1440 3780 1440 {lab=VPWR}
N 3060 1470 3060 1580 {lab=#net16}
N 3080 1440 3080 1580 {lab=VPWR}
N 3060 1440 3080 1440 {lab=VPWR}
N 2860 1650 2970 1650 {lab=#net17}
N 3180 1650 3350 1650 {lab=#net18}
N 3060 1720 3060 1870 {lab=#net19}
N 3080 1720 3080 1900 {lab=VGND}
N 3060 1900 3080 1900 {lab=VGND}
N 2740 1720 2740 1870 {lab=#net20}
N 2760 1720 2760 1900 {lab=VGND}
N 2740 1900 2760 1900 {lab=VGND}
N 3440 1720 3440 1870 {lab=#net21}
N 3460 1720 3460 1900 {lab=VGND}
N 3440 1900 3460 1900 {lab=VGND}
N 3760 1720 3760 1870 {lab=#net22}
N 3780 1720 3780 1900 {lab=VGND}
N 3760 1900 3780 1900 {lab=VGND}
N 3760 1470 3760 1580 {lab=#net23}
N 3460 1440 3460 1580 {lab=VPWR}
N 3440 1440 3460 1440 {lab=VPWR}
N 3440 1470 3440 1580 {lab=#net24}
N 3560 1650 3670 1650 {lab=#net25}
N 4580 1650 4640 1650 {lab=feedback}
N 2430 1290 2740 1290 {lab=VPWR}
N 2410 2050 2740 2050 {lab=VGND}
N 2490 1650 2650 1650 {lab=#net26}
N 2310 2000 2680 2000 {lab=vctl}
N 3800 2050 4140 2050 {lab=VGND}
N 4160 1900 4180 1900 {lab=VGND}
N 4180 1900 4180 2050 {lab=VGND}
N 4140 1930 4140 2050 {lab=VGND}
N 4480 1900 4500 1900 {lab=VGND}
N 4460 1930 4460 2050 {lab=VGND}
N 4160 1440 4200 1440 {lab=VPWR}
N 4140 1290 4140 1410 {lab=VPWR}
N 4480 1440 4520 1440 {lab=VPWR}
N 4460 1290 4460 1410 {lab=VPWR}
N 4180 2050 4460 2050 {lab=VGND}
N 4200 1290 4460 1290 {lab=VPWR}
N 3820 1290 4140 1290 {lab=VPWR}
N 4080 1440 4100 1440 {lab=mirror_pg}
N 4520 1290 4520 1440 {lab=VPWR}
N 4460 1290 4520 1290 {lab=VPWR}
N 4200 1290 4200 1440 {lab=VPWR}
N 4140 1290 4200 1290 {lab=VPWR}
N 4400 1440 4420 1440 {lab=mirror_pg}
N 4080 1900 4100 1900 {lab=vctl}
N 4400 1900 4420 1900 {lab=vctl}
N 4140 2050 4180 2050 {lab=VGND}
N 4500 1900 4500 2050 {lab=VGND}
N 4460 2050 4500 2050 {lab=VGND}
N 4080 2000 4400 2000 {lab=vctl}
N 4400 1900 4400 2000 {lab=vctl}
N 4080 1900 4080 2000 {lab=vctl}
N 3700 2000 4080 2000 {lab=vctl}
N 4480 1440 4480 1580 {lab=VPWR}
N 4460 1440 4480 1440 {lab=VPWR}
N 3880 1650 4050 1650 {lab=#net18}
N 4140 1720 4140 1870 {lab=#net21}
N 4160 1720 4160 1900 {lab=VGND}
N 4140 1900 4160 1900 {lab=VGND}
N 4460 1720 4460 1870 {lab=#net22}
N 4480 1720 4480 1900 {lab=VGND}
N 4460 1900 4480 1900 {lab=VGND}
N 4460 1470 4460 1580 {lab=#net23}
N 4160 1440 4160 1580 {lab=VPWR}
N 4140 1440 4160 1440 {lab=VPWR}
N 4140 1470 4140 1580 {lab=#net24}
N 4260 1650 4370 1650 {lab=#net25}
N 990 860 1250 860 {lab=VGND}
N 800 710 910 710 {lab=vctl}
N 950 710 990 710 {lab=VGND}
N 990 710 990 860 {lab=VGND}
N 950 740 950 860 {lab=VGND}
N 1270 710 1290 710 {lab=VGND}
N 1290 710 1290 860 {lab=VGND}
N 1250 740 1250 860 {lab=VGND}
N 1590 710 1610 710 {lab=VGND}
N 1610 710 1610 860 {lab=VGND}
N 1570 740 1570 860 {lab=VGND}
N 1910 710 1930 710 {lab=VGND}
N 1930 710 1930 860 {lab=VGND}
N 1890 740 1890 860 {lab=VGND}
N 990 100 1250 100 {lab=VPWR}
N 1310 100 1570 100 {lab=VPWR}
N 1630 100 1890 100 {lab=VPWR}
N 950 320 950 680 {lab=mirror_pg}
N 850 250 910 250 {lab=mirror_pg}
N 850 250 850 320 {lab=mirror_pg}
N 850 320 950 320 {lab=mirror_pg}
N 950 280 950 320 {lab=mirror_pg}
N 950 250 990 250 {lab=VPWR}
N 950 100 950 220 {lab=VPWR}
N 1270 250 1310 250 {lab=VPWR}
N 1250 100 1250 220 {lab=VPWR}
N 1590 250 1630 250 {lab=VPWR}
N 1570 100 1570 220 {lab=VPWR}
N 1910 250 1950 250 {lab=VPWR}
N 1890 100 1890 220 {lab=VPWR}
N 1290 860 1570 860 {lab=VGND}
N 1610 860 1890 860 {lab=VGND}
N 4160 660 4160 860 {lab=VGND}
N 1930 860 2270 860 {lab=VGND}
N 4520 660 4520 860 {lab=VGND}
N 4300 860 4520 860 {lab=VGND}
N 2290 710 2310 710 {lab=VGND}
N 2310 710 2310 860 {lab=VGND}
N 2270 740 2270 860 {lab=VGND}
N 2610 710 2630 710 {lab=VGND}
N 2590 740 2590 860 {lab=VGND}
N 2290 250 2330 250 {lab=VPWR}
N 2270 100 2270 220 {lab=VPWR}
N 2610 250 2650 250 {lab=VPWR}
N 2590 100 2590 220 {lab=VPWR}
N 2310 860 2590 860 {lab=VGND}
N 4280 860 4300 860 {lab=VGND}
N 2330 100 2590 100 {lab=VPWR}
N 1950 100 2270 100 {lab=VPWR}
N 4520 460 4520 600 {lab=Vout}
N 830 250 850 250 {lab=mirror_pg}
N 1190 250 1210 250 {lab=mirror_pg}
N 1510 250 1530 250 {lab=mirror_pg}
N 1830 250 1850 250 {lab=mirror_pg}
N 2210 250 2230 250 {lab=mirror_pg}
N 990 100 990 250 {lab=VPWR}
N 950 100 990 100 {lab=VPWR}
N 1310 100 1310 250 {lab=VPWR}
N 1250 100 1310 100 {lab=VPWR}
N 2650 100 2650 250 {lab=VPWR}
N 2590 100 2650 100 {lab=VPWR}
N 2330 100 2330 250 {lab=VPWR}
N 2270 100 2330 100 {lab=VPWR}
N 1950 100 1950 250 {lab=VPWR}
N 1890 100 1950 100 {lab=VPWR}
N 1630 100 1630 250 {lab=VPWR}
N 1570 100 1630 100 {lab=VPWR}
N 2530 250 2550 250 {lab=mirror_pg}
N 1190 710 1210 710 {lab=vctl}
N 1510 710 1530 710 {lab=vctl}
N 1830 710 1850 710 {lab=vctl}
N 2210 710 2230 710 {lab=vctl}
N 2530 710 2550 710 {lab=vctl}
N 950 860 990 860 {lab=VGND}
N 1250 860 1290 860 {lab=VGND}
N 1570 860 1610 860 {lab=VGND}
N 1890 860 1930 860 {lab=VGND}
N 2270 860 2310 860 {lab=VGND}
N 2630 710 2630 860 {lab=VGND}
N 2590 860 2630 860 {lab=VGND}
N 800 710 800 810 {lab=vctl}
N 2210 810 2530 810 {lab=vctl}
N 2530 710 2530 810 {lab=vctl}
N 2210 710 2210 810 {lab=vctl}
N 1830 710 1830 810 {lab=vctl}
N 1830 810 2210 810 {lab=vctl}
N 1510 810 1830 810 {lab=vctl}
N 1510 710 1510 810 {lab=vctl}
N 1190 810 1510 810 {lab=vctl}
N 1190 710 1190 810 {lab=vctl}
N 800 810 1190 810 {lab=vctl}
N 1250 280 1250 390 {lab=#net1}
N 1570 280 1570 390 {lab=#net2}
N 1590 250 1590 390 {lab=VPWR}
N 1570 250 1590 250 {lab=VPWR}
N 1270 250 1270 390 {lab=VPWR}
N 1250 250 1270 250 {lab=VPWR}
N 4160 460 4190 460 {lab=feedback}
N 2610 250 2610 390 {lab=VPWR}
N 2590 250 2610 250 {lab=VPWR}
N 1890 280 1890 390 {lab=#net3}
N 1910 250 1910 390 {lab=VPWR}
N 1890 250 1910 250 {lab=VPWR}
N 1070 460 1160 460 {lab=feedback}
N 1370 460 1490 460 {lab=#net4}
N 1690 460 1800 460 {lab=#net5}
N 2010 460 2180 460 {lab=#net6}
N 1890 530 1890 680 {lab=#net7}
N 1910 530 1910 710 {lab=VGND}
N 1890 710 1910 710 {lab=VGND}
N 1570 530 1570 680 {lab=#net8}
N 1590 530 1590 710 {lab=VGND}
N 1570 710 1590 710 {lab=VGND}
N 1250 530 1250 680 {lab=#net9}
N 1270 530 1270 710 {lab=VGND}
N 1250 710 1270 710 {lab=VGND}
N 2270 530 2270 680 {lab=#net10}
N 2290 530 2290 710 {lab=VGND}
N 2270 710 2290 710 {lab=VGND}
N 2590 530 2590 680 {lab=#net11}
N 2610 530 2610 710 {lab=VGND}
N 2590 710 2610 710 {lab=VGND}
N 4300 530 4300 860 {lab=VGND}
N 4280 530 4280 860 {lab=VGND}
N 4160 860 4280 860 {lab=VGND}
N 4280 100 4280 390 {lab=VPWR}
N 4300 100 4300 390 {lab=VPWR}
N 4280 100 4300 100 {lab=VPWR}
N 2590 280 2590 390 {lab=#net12}
N 2290 250 2290 390 {lab=VPWR}
N 2270 250 2290 250 {lab=VPWR}
N 2270 280 2270 390 {lab=#net13}
N 2390 460 2500 460 {lab=#net14}
N 4400 460 4520 460 {lab=Vout}
N 4160 460 4160 600 {lab=feedback}
N 2980 710 3000 710 {lab=VGND}
N 3000 710 3000 860 {lab=VGND}
N 2960 740 2960 860 {lab=VGND}
N 3300 710 3320 710 {lab=VGND}
N 3320 710 3320 860 {lab=VGND}
N 3280 740 3280 860 {lab=VGND}
N 3020 100 3280 100 {lab=VPWR}
N 2980 250 3020 250 {lab=VPWR}
N 2960 100 2960 220 {lab=VPWR}
N 3300 250 3340 250 {lab=VPWR}
N 3280 100 3280 220 {lab=VPWR}
N 3000 860 3280 860 {lab=VGND}
N 4040 100 4280 100 {lab=VPWR}
N 3320 860 3660 860 {lab=VGND}
N 3680 710 3700 710 {lab=VGND}
N 3700 710 3700 860 {lab=VGND}
N 3660 740 3660 860 {lab=VGND}
N 4000 710 4020 710 {lab=VGND}
N 3980 740 3980 860 {lab=VGND}
N 3680 250 3720 250 {lab=VPWR}
N 3660 100 3660 220 {lab=VPWR}
N 4000 250 4040 250 {lab=VPWR}
N 3980 100 3980 220 {lab=VPWR}
N 3700 860 3980 860 {lab=VGND}
N 3720 100 3980 100 {lab=VPWR}
N 3340 100 3660 100 {lab=VPWR}
N 2900 250 2920 250 {lab=mirror_pg}
N 3220 250 3240 250 {lab=mirror_pg}
N 3600 250 3620 250 {lab=mirror_pg}
N 4040 100 4040 250 {lab=VPWR}
N 3980 100 4040 100 {lab=VPWR}
N 3720 100 3720 250 {lab=VPWR}
N 3660 100 3720 100 {lab=VPWR}
N 3340 100 3340 250 {lab=VPWR}
N 3280 100 3340 100 {lab=VPWR}
N 3020 100 3020 250 {lab=VPWR}
N 2960 100 3020 100 {lab=VPWR}
N 3920 250 3940 250 {lab=mirror_pg}
N 2900 710 2920 710 {lab=vctl}
N 3220 710 3240 710 {lab=vctl}
N 3600 710 3620 710 {lab=vctl}
N 3920 710 3940 710 {lab=vctl}
N 2960 860 3000 860 {lab=VGND}
N 3280 860 3320 860 {lab=VGND}
N 3660 860 3700 860 {lab=VGND}
N 4020 710 4020 860 {lab=VGND}
N 3980 860 4020 860 {lab=VGND}
N 3600 810 3920 810 {lab=vctl}
N 3920 710 3920 810 {lab=vctl}
N 3600 710 3600 810 {lab=vctl}
N 3220 710 3220 810 {lab=vctl}
N 3220 810 3600 810 {lab=vctl}
N 2900 810 3220 810 {lab=vctl}
N 2900 710 2900 810 {lab=vctl}
N 2960 280 2960 390 {lab=#net15}
N 2980 250 2980 390 {lab=VPWR}
N 2960 250 2980 250 {lab=VPWR}
N 4020 860 4160 860 {lab=VGND}
N 4000 250 4000 390 {lab=VPWR}
N 3980 250 4000 250 {lab=VPWR}
N 3280 280 3280 390 {lab=#net16}
N 3300 250 3300 390 {lab=VPWR}
N 3280 250 3300 250 {lab=VPWR}
N 3080 460 3190 460 {lab=#net17}
N 3400 460 3570 460 {lab=#net18}
N 3280 530 3280 680 {lab=#net19}
N 3300 530 3300 710 {lab=VGND}
N 3280 710 3300 710 {lab=VGND}
N 2960 530 2960 680 {lab=#net20}
N 2980 530 2980 710 {lab=VGND}
N 2960 710 2980 710 {lab=VGND}
N 3660 530 3660 680 {lab=#net21}
N 3680 530 3680 710 {lab=VGND}
N 3660 710 3680 710 {lab=VGND}
N 3980 530 3980 680 {lab=#net22}
N 4000 530 4000 710 {lab=VGND}
N 3980 710 4000 710 {lab=VGND}
N 3980 280 3980 390 {lab=#net23}
N 3680 250 3680 390 {lab=VPWR}
N 3660 250 3680 250 {lab=VPWR}
N 3660 280 3660 390 {lab=#net24}
N 3780 460 3890 460 {lab=#net25}
N 4100 460 4160 460 {lab=feedback}
N 2650 100 2960 100 {lab=VPWR}
N 2630 860 2960 860 {lab=VGND}
N 2710 460 2870 460 {lab=#net26}
N 2530 810 2900 810 {lab=vctl}
N 740 3090 1000 3090 {lab=VGND}
N 550 2940 660 2940 {lab=vctl}
N 700 2940 740 2940 {lab=VGND}
N 740 2940 740 3090 {lab=VGND}
N 700 2970 700 3090 {lab=VGND}
N 1020 2940 1040 2940 {lab=VGND}
N 1040 2940 1040 3090 {lab=VGND}
N 1000 2970 1000 3090 {lab=VGND}
N 1340 2940 1360 2940 {lab=VGND}
N 1360 2940 1360 3090 {lab=VGND}
N 1320 2970 1320 3090 {lab=VGND}
N 1660 2940 1680 2940 {lab=VGND}
N 1680 2940 1680 3090 {lab=VGND}
N 1640 2970 1640 3090 {lab=VGND}
N 740 2330 1000 2330 {lab=VPWR}
N 1060 2330 1320 2330 {lab=VPWR}
N 1380 2330 1640 2330 {lab=VPWR}
N 700 2550 700 2910 {lab=mirror_pg}
N 600 2480 660 2480 {lab=mirror_pg}
N 600 2480 600 2550 {lab=mirror_pg}
N 600 2550 700 2550 {lab=mirror_pg}
N 700 2510 700 2550 {lab=mirror_pg}
N 700 2480 740 2480 {lab=VPWR}
N 700 2330 700 2450 {lab=VPWR}
N 1020 2480 1060 2480 {lab=VPWR}
N 1000 2330 1000 2450 {lab=VPWR}
N 1340 2480 1380 2480 {lab=VPWR}
N 1320 2330 1320 2450 {lab=VPWR}
N 1660 2480 1700 2480 {lab=VPWR}
N 1640 2330 1640 2450 {lab=VPWR}
N 1040 3090 1320 3090 {lab=VGND}
N 1360 3090 1640 3090 {lab=VGND}
N 5310 2890 5310 3090 {lab=VGND}
N 1680 3090 2020 3090 {lab=VGND}
N 5670 2890 5670 3090 {lab=VGND}
N 5450 3090 5670 3090 {lab=VGND}
N 2040 2940 2060 2940 {lab=VGND}
N 2060 2940 2060 3090 {lab=VGND}
N 2020 2970 2020 3090 {lab=VGND}
N 2360 2940 2380 2940 {lab=VGND}
N 2340 2970 2340 3090 {lab=VGND}
N 2040 2480 2080 2480 {lab=VPWR}
N 2020 2330 2020 2450 {lab=VPWR}
N 2360 2480 2400 2480 {lab=VPWR}
N 2340 2330 2340 2450 {lab=VPWR}
N 2060 3090 2340 3090 {lab=VGND}
N 5430 3090 5450 3090 {lab=VGND}
N 2080 2330 2340 2330 {lab=VPWR}
N 1700 2330 2020 2330 {lab=VPWR}
N 5670 2690 5670 2830 {lab=Vout}
N 580 2480 600 2480 {lab=mirror_pg}
N 940 2480 960 2480 {lab=mirror_pg}
N 1260 2480 1280 2480 {lab=mirror_pg}
N 1580 2480 1600 2480 {lab=mirror_pg}
N 1960 2480 1980 2480 {lab=mirror_pg}
N 740 2330 740 2480 {lab=VPWR}
N 700 2330 740 2330 {lab=VPWR}
N 1060 2330 1060 2480 {lab=VPWR}
N 1000 2330 1060 2330 {lab=VPWR}
N 2400 2330 2400 2480 {lab=VPWR}
N 2340 2330 2400 2330 {lab=VPWR}
N 2080 2330 2080 2480 {lab=VPWR}
N 2020 2330 2080 2330 {lab=VPWR}
N 1700 2330 1700 2480 {lab=VPWR}
N 1640 2330 1700 2330 {lab=VPWR}
N 1380 2330 1380 2480 {lab=VPWR}
N 1320 2330 1380 2330 {lab=VPWR}
N 2280 2480 2300 2480 {lab=mirror_pg}
N 940 2940 960 2940 {lab=vctl}
N 1260 2940 1280 2940 {lab=vctl}
N 1580 2940 1600 2940 {lab=vctl}
N 1960 2940 1980 2940 {lab=vctl}
N 2280 2940 2300 2940 {lab=vctl}
N 700 3090 740 3090 {lab=VGND}
N 1000 3090 1040 3090 {lab=VGND}
N 1320 3090 1360 3090 {lab=VGND}
N 1640 3090 1680 3090 {lab=VGND}
N 2020 3090 2060 3090 {lab=VGND}
N 2380 2940 2380 3090 {lab=VGND}
N 2340 3090 2380 3090 {lab=VGND}
N 550 2940 550 3040 {lab=vctl}
N 1960 3040 2280 3040 {lab=vctl}
N 2280 2940 2280 3040 {lab=vctl}
N 1960 2940 1960 3040 {lab=vctl}
N 1580 2940 1580 3040 {lab=vctl}
N 1580 3040 1960 3040 {lab=vctl}
N 1260 3040 1580 3040 {lab=vctl}
N 1260 2940 1260 3040 {lab=vctl}
N 940 3040 1260 3040 {lab=vctl}
N 940 2940 940 3040 {lab=vctl}
N 550 3040 940 3040 {lab=vctl}
N 1000 2510 1000 2620 {lab=#net1}
N 1320 2510 1320 2620 {lab=#net2}
N 1340 2480 1340 2620 {lab=VPWR}
N 1320 2480 1340 2480 {lab=VPWR}
N 1020 2480 1020 2620 {lab=VPWR}
N 1000 2480 1020 2480 {lab=VPWR}
N 5310 2690 5340 2690 {lab=feedback}
N 2360 2480 2360 2620 {lab=VPWR}
N 2340 2480 2360 2480 {lab=VPWR}
N 1640 2510 1640 2620 {lab=#net3}
N 1660 2480 1660 2620 {lab=VPWR}
N 1640 2480 1660 2480 {lab=VPWR}
N 820 2690 910 2690 {lab=feedback}
N 1120 2690 1240 2690 {lab=#net4}
N 1440 2690 1550 2690 {lab=#net5}
N 1760 2690 1930 2690 {lab=#net6}
N 1640 2760 1640 2910 {lab=#net7}
N 1660 2760 1660 2940 {lab=VGND}
N 1640 2940 1660 2940 {lab=VGND}
N 1320 2760 1320 2910 {lab=#net8}
N 1340 2760 1340 2940 {lab=VGND}
N 1320 2940 1340 2940 {lab=VGND}
N 1000 2760 1000 2910 {lab=#net9}
N 1020 2760 1020 2940 {lab=VGND}
N 1000 2940 1020 2940 {lab=VGND}
N 2020 2760 2020 2910 {lab=#net10}
N 2040 2760 2040 2940 {lab=VGND}
N 2020 2940 2040 2940 {lab=VGND}
N 2340 2760 2340 2910 {lab=#net11}
N 2360 2760 2360 2940 {lab=VGND}
N 2340 2940 2360 2940 {lab=VGND}
N 5450 2760 5450 3090 {lab=VGND}
N 5430 2760 5430 3090 {lab=VGND}
N 5310 3090 5430 3090 {lab=VGND}
N 5430 2330 5430 2620 {lab=VPWR}
N 5450 2330 5450 2620 {lab=VPWR}
N 5430 2330 5450 2330 {lab=VPWR}
N 2340 2510 2340 2620 {lab=#net12}
N 2040 2480 2040 2620 {lab=VPWR}
N 2020 2480 2040 2480 {lab=VPWR}
N 2020 2510 2020 2620 {lab=#net13}
N 2140 2690 2250 2690 {lab=#net14}
N 5550 2690 5670 2690 {lab=Vout}
N 5310 2690 5310 2830 {lab=feedback}
N 2730 2940 2750 2940 {lab=VGND}
N 2750 2940 2750 3090 {lab=VGND}
N 2710 2970 2710 3090 {lab=VGND}
N 3050 2940 3070 2940 {lab=VGND}
N 3070 2940 3070 3090 {lab=VGND}
N 3030 2970 3030 3090 {lab=VGND}
N 2770 2330 3030 2330 {lab=VPWR}
N 2730 2480 2770 2480 {lab=VPWR}
N 2710 2330 2710 2450 {lab=VPWR}
N 3050 2480 3090 2480 {lab=VPWR}
N 3030 2330 3030 2450 {lab=VPWR}
N 2750 3090 3030 3090 {lab=VGND}
N 5190 2330 5430 2330 {lab=VPWR}
N 3070 3090 3410 3090 {lab=VGND}
N 3430 2940 3450 2940 {lab=VGND}
N 3450 2940 3450 3090 {lab=VGND}
N 3410 2970 3410 3090 {lab=VGND}
N 3750 2940 3770 2940 {lab=VGND}
N 3730 2970 3730 3090 {lab=VGND}
N 3430 2480 3470 2480 {lab=VPWR}
N 3410 2330 3410 2450 {lab=VPWR}
N 3750 2480 3790 2480 {lab=VPWR}
N 3730 2330 3730 2450 {lab=VPWR}
N 3450 3090 3730 3090 {lab=VGND}
N 3470 2330 3730 2330 {lab=VPWR}
N 3090 2330 3410 2330 {lab=VPWR}
N 2650 2480 2670 2480 {lab=mirror_pg}
N 2970 2480 2990 2480 {lab=mirror_pg}
N 3350 2480 3370 2480 {lab=mirror_pg}
N 3790 2330 3790 2480 {lab=VPWR}
N 3730 2330 3790 2330 {lab=VPWR}
N 3470 2330 3470 2480 {lab=VPWR}
N 3410 2330 3470 2330 {lab=VPWR}
N 3090 2330 3090 2480 {lab=VPWR}
N 3030 2330 3090 2330 {lab=VPWR}
N 2770 2330 2770 2480 {lab=VPWR}
N 2710 2330 2770 2330 {lab=VPWR}
N 3670 2480 3690 2480 {lab=mirror_pg}
N 2650 2940 2670 2940 {lab=vctl}
N 2970 2940 2990 2940 {lab=vctl}
N 3350 2940 3370 2940 {lab=vctl}
N 3670 2940 3690 2940 {lab=vctl}
N 2710 3090 2750 3090 {lab=VGND}
N 3030 3090 3070 3090 {lab=VGND}
N 3410 3090 3450 3090 {lab=VGND}
N 3770 2940 3770 3090 {lab=VGND}
N 3730 3090 3770 3090 {lab=VGND}
N 3350 3040 3670 3040 {lab=vctl}
N 3670 2940 3670 3040 {lab=vctl}
N 3350 2940 3350 3040 {lab=vctl}
N 2970 2940 2970 3040 {lab=vctl}
N 2970 3040 3350 3040 {lab=vctl}
N 2650 3040 2970 3040 {lab=vctl}
N 2650 2940 2650 3040 {lab=vctl}
N 2710 2510 2710 2620 {lab=#net15}
N 2730 2480 2730 2620 {lab=VPWR}
N 2710 2480 2730 2480 {lab=VPWR}
N 5170 3090 5310 3090 {lab=VGND}
N 3750 2480 3750 2620 {lab=VPWR}
N 3730 2480 3750 2480 {lab=VPWR}
N 3030 2510 3030 2620 {lab=#net16}
N 3050 2480 3050 2620 {lab=VPWR}
N 3030 2480 3050 2480 {lab=VPWR}
N 2830 2690 2940 2690 {lab=#net17}
N 3150 2690 3320 2690 {lab=#net18}
N 3030 2760 3030 2910 {lab=#net19}
N 3050 2760 3050 2940 {lab=VGND}
N 3030 2940 3050 2940 {lab=VGND}
N 2710 2760 2710 2910 {lab=#net20}
N 2730 2760 2730 2940 {lab=VGND}
N 2710 2940 2730 2940 {lab=VGND}
N 3410 2760 3410 2910 {lab=#net21}
N 3430 2760 3430 2940 {lab=VGND}
N 3410 2940 3430 2940 {lab=VGND}
N 3730 2760 3730 2910 {lab=#net22}
N 3750 2760 3750 2940 {lab=VGND}
N 3730 2940 3750 2940 {lab=VGND}
N 3730 2510 3730 2620 {lab=#net23}
N 3430 2480 3430 2620 {lab=VPWR}
N 3410 2480 3430 2480 {lab=VPWR}
N 3410 2510 3410 2620 {lab=#net24}
N 3530 2690 3640 2690 {lab=#net25}
N 5250 2690 5310 2690 {lab=feedback}
N 2400 2330 2710 2330 {lab=VPWR}
N 2380 3090 2710 3090 {lab=VGND}
N 2460 2690 2620 2690 {lab=#net26}
N 2280 3040 2650 3040 {lab=vctl}
N 3770 3090 4110 3090 {lab=VGND}
N 4130 2940 4150 2940 {lab=VGND}
N 4150 2940 4150 3090 {lab=VGND}
N 4110 2970 4110 3090 {lab=VGND}
N 4450 2940 4470 2940 {lab=VGND}
N 4430 2970 4430 3090 {lab=VGND}
N 4130 2480 4170 2480 {lab=VPWR}
N 4110 2330 4110 2450 {lab=VPWR}
N 4450 2480 4490 2480 {lab=VPWR}
N 4430 2330 4430 2450 {lab=VPWR}
N 4150 3090 4430 3090 {lab=VGND}
N 4170 2330 4430 2330 {lab=VPWR}
N 3790 2330 4110 2330 {lab=VPWR}
N 4050 2480 4070 2480 {lab=mirror_pg}
N 4490 2330 4490 2480 {lab=VPWR}
N 4430 2330 4490 2330 {lab=VPWR}
N 4170 2330 4170 2480 {lab=VPWR}
N 4110 2330 4170 2330 {lab=VPWR}
N 4370 2480 4390 2480 {lab=mirror_pg}
N 4050 2940 4070 2940 {lab=vctl}
N 4370 2940 4390 2940 {lab=vctl}
N 4110 3090 4150 3090 {lab=VGND}
N 4470 2940 4470 3090 {lab=VGND}
N 4430 3090 4470 3090 {lab=VGND}
N 4050 3040 4370 3040 {lab=vctl}
N 4370 2940 4370 3040 {lab=vctl}
N 4050 2940 4050 3040 {lab=vctl}
N 3670 3040 4050 3040 {lab=vctl}
N 4450 2480 4450 2620 {lab=VPWR}
N 4430 2480 4450 2480 {lab=VPWR}
N 3850 2690 4020 2690 {lab=#net18}
N 4110 2760 4110 2910 {lab=#net21}
N 4130 2760 4130 2940 {lab=VGND}
N 4110 2940 4130 2940 {lab=VGND}
N 4430 2760 4430 2910 {lab=#net22}
N 4450 2760 4450 2940 {lab=VGND}
N 4430 2940 4450 2940 {lab=VGND}
N 4430 2510 4430 2620 {lab=#net23}
N 4130 2480 4130 2620 {lab=VPWR}
N 4110 2480 4130 2480 {lab=VPWR}
N 4110 2510 4110 2620 {lab=#net24}
N 4230 2690 4340 2690 {lab=#net25}
N 4470 3090 4810 3090 {lab=VGND}
N 4830 2940 4850 2940 {lab=VGND}
N 4850 2940 4850 3090 {lab=VGND}
N 4810 2970 4810 3090 {lab=VGND}
N 5150 2940 5170 2940 {lab=VGND}
N 5130 2970 5130 3090 {lab=VGND}
N 4830 2480 4870 2480 {lab=VPWR}
N 4810 2330 4810 2450 {lab=VPWR}
N 5150 2480 5190 2480 {lab=VPWR}
N 5130 2330 5130 2450 {lab=VPWR}
N 4850 3090 5130 3090 {lab=VGND}
N 4870 2330 5130 2330 {lab=VPWR}
N 4490 2330 4810 2330 {lab=VPWR}
N 4750 2480 4770 2480 {lab=mirror_pg}
N 5190 2330 5190 2480 {lab=VPWR}
N 5130 2330 5190 2330 {lab=VPWR}
N 4870 2330 4870 2480 {lab=VPWR}
N 4810 2330 4870 2330 {lab=VPWR}
N 5070 2480 5090 2480 {lab=mirror_pg}
N 4750 2940 4770 2940 {lab=vctl}
N 5070 2940 5090 2940 {lab=vctl}
N 4810 3090 4850 3090 {lab=VGND}
N 5170 2940 5170 3090 {lab=VGND}
N 5130 3090 5170 3090 {lab=VGND}
N 4750 3040 5070 3040 {lab=vctl}
N 5070 2940 5070 3040 {lab=vctl}
N 4750 2940 4750 3040 {lab=vctl}
N 4370 3040 4750 3040 {lab=vctl}
N 5150 2480 5150 2620 {lab=VPWR}
N 5130 2480 5150 2480 {lab=VPWR}
N 4550 2690 4720 2690 {lab=#net18}
N 4810 2760 4810 2910 {lab=#net21}
N 4830 2760 4830 2940 {lab=VGND}
N 4810 2940 4830 2940 {lab=VGND}
N 5130 2760 5130 2910 {lab=#net22}
N 5150 2760 5150 2940 {lab=VGND}
N 5130 2940 5150 2940 {lab=VGND}
N 5130 2510 5130 2620 {lab=#net23}
N 4830 2480 4830 2620 {lab=VPWR}
N 4810 2480 4830 2480 {lab=VPWR}
N 4810 2510 4810 2620 {lab=#net24}
N 4930 2690 5040 2690 {lab=#net25}
C {sg13g2_pr/sg13_lv_pmos.sym} 710 1440 0 0 {name=M21
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1010 1440 0 0 {name=M22
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1330 1440 0 0 {name=M23
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1650 1440 0 0 {name=M24
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 710 1900 0 0 {name=M25
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1010 1900 0 0 {name=M26
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1330 1900 0 0 {name=M27
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1650 1900 0 0 {name=M28
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {capa.sym} 4640 1820 0 0 {name=C3
m=1
value=10f
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 5000 1820 0 0 {name=C4
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {sg13g2_pr/sg13_lv_pmos.sym} 2030 1440 0 0 {name=M29
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2350 1440 0 0 {name=M30
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2030 1900 0 0 {name=M31
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2350 1900 0 0 {name=M32
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 850 1650 2 1 {name=p21 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 4600 1650 3 1 {name=p22 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 610 1440 2 1 {name=p23 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 970 1440 2 1 {name=p24 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1290 1440 2 1 {name=p25 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1610 1440 2 1 {name=p26 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1990 1440 2 1 {name=p27 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 2310 1440 2 1 {name=p28 sig_type=std_logic lab=mirror_pg
}
C {iopin.sym} 400 1130 0 1 {name=p29 lab=VPWR}
C {iopin.sym} 400 1160 0 1 {name=p30 lab=VGND}
C {ipin.sym} 400 1200 0 0 {name=p31 lab=vctl}
C {opin.sym} 380 1260 0 0 {name=p32 lab=Vout}
C {lab_pin.sym} 590 1900 2 1 {name=p33 sig_type=std_logic lab=vctl
}
C {lab_pin.sym} 730 2050 2 1 {name=p34 sig_type=std_logic lab=VGND
}
C {lab_pin.sym} 730 1300 2 1 {name=p35 sig_type=std_logic lab=VPWR
}
C {lab_pin.sym} 5000 1650 2 0 {name=p36 sig_type=std_logic lab=Vout
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1040 1650 0 0 {name=x11}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1360 1650 0 0 {name=x12}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1680 1650 0 0 {name=x13}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2060 1650 0 0 {name=x14}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2380 1650 0 0 {name=x15}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4770 1650 0 0 {name=x16}
C {sg13g2_pr/sg13_lv_pmos.sym} 2720 1440 0 0 {name=M33
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3040 1440 0 0 {name=M34
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 1900 0 0 {name=M35
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3040 1900 0 0 {name=M36
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3420 1440 0 0 {name=M37
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3740 1440 0 0 {name=M38
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3420 1900 0 0 {name=M39
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 1900 0 0 {name=M40
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 2680 1440 2 1 {name=p37 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3000 1440 2 1 {name=p38 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3380 1440 2 1 {name=p39 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3700 1440 2 1 {name=p40 sig_type=std_logic lab=mirror_pg
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2750 1650 0 0 {name=x17}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3070 1650 0 0 {name=x18}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3450 1650 0 0 {name=x19}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3770 1650 0 0 {name=x20}
C {sg13g2_pr/sg13_lv_pmos.sym} 4120 1440 0 0 {name=M41
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4440 1440 0 0 {name=M42
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4120 1900 0 0 {name=M43
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4440 1900 0 0 {name=M44
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 4080 1440 2 1 {name=p41 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 4400 1440 2 1 {name=p42 sig_type=std_logic lab=mirror_pg
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4150 1650 0 0 {name=x21}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4470 1650 0 0 {name=x22}
C {sg13g2_pr/sg13_lv_pmos.sym} 930 250 0 0 {name=M1
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1230 250 0 0 {name=M2
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1550 250 0 0 {name=M3
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 250 0 0 {name=M4
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 930 710 0 0 {name=M5
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1230 710 0 0 {name=M6
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1550 710 0 0 {name=M7
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1870 710 0 0 {name=M8
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {capa.sym} 4160 630 0 0 {name=C1
m=1
value=10f
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 4520 630 0 0 {name=C2
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {sg13g2_pr/sg13_lv_pmos.sym} 2250 250 0 0 {name=M9
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2570 250 0 0 {name=M10
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2250 710 0 0 {name=M11
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2570 710 0 0 {name=M12
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 1070 460 2 1 {name=p15 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 4120 460 3 1 {name=p6 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 830 250 2 1 {name=p7 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1190 250 2 1 {name=p8 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1510 250 2 1 {name=p9 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1830 250 2 1 {name=p10 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 2210 250 2 1 {name=p11 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 2530 250 2 1 {name=p12 sig_type=std_logic lab=mirror_pg
}
C {iopin.sym} 620 -60 0 1 {name=p1 lab=VPWR}
C {iopin.sym} 620 -30 0 1 {name=p4 lab=VGND}
C {ipin.sym} 620 10 0 0 {name=p13 lab=vctl}
C {opin.sym} 600 70 0 0 {name=p17 lab=Vout}
C {lab_pin.sym} 810 710 2 1 {name=p14 sig_type=std_logic lab=vctl
}
C {lab_pin.sym} 950 860 2 1 {name=p16 sig_type=std_logic lab=VGND
}
C {lab_pin.sym} 950 110 2 1 {name=p18 sig_type=std_logic lab=VPWR
}
C {lab_pin.sym} 4520 460 2 0 {name=p2 sig_type=std_logic lab=Vout
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1260 460 0 0 {name=x7}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1580 460 0 0 {name=x1}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1900 460 0 0 {name=x2}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2280 460 0 0 {name=x3}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2600 460 0 0 {name=x4}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4290 460 0 0 {name=x5}
C {sg13g2_pr/sg13_lv_pmos.sym} 2940 250 0 0 {name=M13
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3260 250 0 0 {name=M14
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2940 710 0 0 {name=M15
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3260 710 0 0 {name=M16
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3640 250 0 0 {name=M17
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3960 250 0 0 {name=M18
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3640 710 0 0 {name=M19
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3960 710 0 0 {name=M20
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 2900 250 2 1 {name=p3 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3220 250 2 1 {name=p5 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3600 250 2 1 {name=p19 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3920 250 2 1 {name=p20 sig_type=std_logic lab=mirror_pg
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2970 460 0 0 {name=x6}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3290 460 0 0 {name=x8}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3670 460 0 0 {name=x9}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3990 460 0 0 {name=x10}
C {sg13g2_pr/sg13_lv_pmos.sym} 680 2480 0 0 {name=M45
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 980 2480 0 0 {name=M46
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1300 2480 0 0 {name=M47
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1620 2480 0 0 {name=M48
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 680 2940 0 0 {name=M49
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 980 2940 0 0 {name=M50
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1300 2940 0 0 {name=M51
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1620 2940 0 0 {name=M52
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {capa.sym} 5310 2860 0 0 {name=C5
m=1
value=10f
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 5670 2860 0 0 {name=C6
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {sg13g2_pr/sg13_lv_pmos.sym} 2000 2480 0 0 {name=M53
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2320 2480 0 0 {name=M54
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2000 2940 0 0 {name=M55
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2320 2940 0 0 {name=M56
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 820 2690 2 1 {name=p43 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 5270 2690 3 1 {name=p44 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 580 2480 2 1 {name=p45 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 940 2480 2 1 {name=p46 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1260 2480 2 1 {name=p47 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1580 2480 2 1 {name=p48 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1960 2480 2 1 {name=p49 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 2280 2480 2 1 {name=p50 sig_type=std_logic lab=mirror_pg
}
C {iopin.sym} 370 2170 0 1 {name=p51 lab=VPWR}
C {iopin.sym} 370 2200 0 1 {name=p52 lab=VGND}
C {ipin.sym} 370 2240 0 0 {name=p53 lab=vctl}
C {opin.sym} 350 2300 0 0 {name=p54 lab=Vout}
C {lab_pin.sym} 560 2940 2 1 {name=p55 sig_type=std_logic lab=vctl
}
C {lab_pin.sym} 700 3090 2 1 {name=p56 sig_type=std_logic lab=VGND
}
C {lab_pin.sym} 700 2340 2 1 {name=p57 sig_type=std_logic lab=VPWR
}
C {lab_pin.sym} 5670 2690 2 0 {name=p58 sig_type=std_logic lab=Vout
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1010 2690 0 0 {name=x23}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1330 2690 0 0 {name=x24}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1650 2690 0 0 {name=x25}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2030 2690 0 0 {name=x26}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2350 2690 0 0 {name=x27}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 5440 2690 0 0 {name=x28}
C {sg13g2_pr/sg13_lv_pmos.sym} 2690 2480 0 0 {name=M57
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3010 2480 0 0 {name=M58
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2690 2940 0 0 {name=M59
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3010 2940 0 0 {name=M60
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3390 2480 0 0 {name=M61
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3710 2480 0 0 {name=M62
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3390 2940 0 0 {name=M63
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3710 2940 0 0 {name=M64
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 2650 2480 2 1 {name=p59 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 2970 2480 2 1 {name=p60 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3350 2480 2 1 {name=p61 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3670 2480 2 1 {name=p62 sig_type=std_logic lab=mirror_pg
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2720 2690 0 0 {name=x29}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3040 2690 0 0 {name=x30}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3420 2690 0 0 {name=x31}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3740 2690 0 0 {name=x32}
C {sg13g2_pr/sg13_lv_pmos.sym} 4090 2480 0 0 {name=M65
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4410 2480 0 0 {name=M66
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4090 2940 0 0 {name=M67
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4410 2940 0 0 {name=M68
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 4050 2480 2 1 {name=p63 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 4370 2480 2 1 {name=p64 sig_type=std_logic lab=mirror_pg
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4120 2690 0 0 {name=x33}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4440 2690 0 0 {name=x34}
C {sg13g2_pr/sg13_lv_pmos.sym} 4790 2480 0 0 {name=M69
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5110 2480 0 0 {name=M70
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4790 2940 0 0 {name=M71
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5110 2940 0 0 {name=M72
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 4750 2480 2 1 {name=p65 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 5070 2480 2 1 {name=p66 sig_type=std_logic lab=mirror_pg
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4820 2690 0 0 {name=x35}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 5140 2690 0 0 {name=x36}
C {sg13g2_pr/sg13_lv_pmos.sym} 930 250 0 0 {name=M73
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1230 250 0 0 {name=M74
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1550 250 0 0 {name=M75
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 250 0 0 {name=M76
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 930 710 0 0 {name=M77
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1230 710 0 0 {name=M78
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1550 710 0 0 {name=M79
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1870 710 0 0 {name=M80
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {capa.sym} 4160 630 0 0 {name=C7
m=1
value=10f
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 4520 630 0 0 {name=C8
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {sg13g2_pr/sg13_lv_pmos.sym} 2250 250 0 0 {name=M81
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2570 250 0 0 {name=M82
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2250 710 0 0 {name=M83
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2570 710 0 0 {name=M84
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 1070 460 2 1 {name=p67 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 4120 460 3 1 {name=p68 sig_type=std_logic lab=feedback
}
C {lab_pin.sym} 830 250 2 1 {name=p69 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1190 250 2 1 {name=p70 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1510 250 2 1 {name=p71 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 1830 250 2 1 {name=p72 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 2210 250 2 1 {name=p73 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 2530 250 2 1 {name=p74 sig_type=std_logic lab=mirror_pg
}
C {iopin.sym} 620 -60 0 1 {name=p75 lab=VPWR}
C {iopin.sym} 620 -30 0 1 {name=p76 lab=VGND}
C {ipin.sym} 620 10 0 0 {name=p77 lab=vctl}
C {opin.sym} 600 70 0 0 {name=p78 lab=Vout}
C {lab_pin.sym} 810 710 2 1 {name=p79 sig_type=std_logic lab=vctl
}
C {lab_pin.sym} 950 860 2 1 {name=p80 sig_type=std_logic lab=VGND
}
C {lab_pin.sym} 950 110 2 1 {name=p81 sig_type=std_logic lab=VPWR
}
C {lab_pin.sym} 4520 460 2 0 {name=p82 sig_type=std_logic lab=Vout
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1260 460 0 0 {name=x37}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1580 460 0 0 {name=x38}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 1900 460 0 0 {name=x39}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2280 460 0 0 {name=x40}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2600 460 0 0 {name=x41}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 4290 460 0 0 {name=x42}
C {sg13g2_pr/sg13_lv_pmos.sym} 2940 250 0 0 {name=M85
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3260 250 0 0 {name=M86
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2940 710 0 0 {name=M87
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3260 710 0 0 {name=M88
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3640 250 0 0 {name=M89
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3960 250 0 0 {name=M90
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3640 710 0 0 {name=M91
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3960 710 0 0 {name=M92
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 2900 250 2 1 {name=p83 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3220 250 2 1 {name=p84 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3600 250 2 1 {name=p85 sig_type=std_logic lab=mirror_pg
}
C {lab_pin.sym} 3920 250 2 1 {name=p86 sig_type=std_logic lab=mirror_pg
}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 2970 460 0 0 {name=x43}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3290 460 0 0 {name=x44}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3670 460 0 0 {name=x45}
C {/foss/designs/cmos-pll-ihp-sg13g2/Team 2 Design/design_data/xschem/t2_vco_inverter.sym} 3990 460 0 0 {name=x46}
