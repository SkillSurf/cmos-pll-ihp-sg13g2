* Circuit, the repository's netlist (same transistors, sizes and wiring as the shapes)
* Extracted by KLayout with SG13G2 LVS runset on : 12/08/2025 11:42

.SUBCKT 3bit_freq_divider 1 2 3 5 10 12 15 17
X$1 13 5 1 sg13g2_tiehi
X$2 6 11 11 15 1 13 5 dff_nclk
X$3 5 1 8 9 7 6 sg13g2_or3_1
X$4 16 14 4 12 7 1 6 5 freq_div_cell
X$5 18 16 4 17 8 1 6 5 freq_div_cell
X$6 18 5 1 sg13g2_tiehi
X$7 14 19 4 10 9 1 6 5 freq_div_cell
X$8 5 1 4 3 2 sg13g2_nand2_1
.ENDS 3bit_freq_divider

.SUBCKT sg13g2_nand2_1 1 2 3 4 5
M$1 2 5 6 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.2516p AD=0.0666p PS=2.16u PD=0.92u
M$2 6 4 3 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.0666p AD=0.2516p PS=0.92u PD=2.16u
M$3 1 5 3 1 sg13_lv_pmos L=0.13u W=1.12u AS=0.3808p AD=0.2128p PS=2.92u PD=1.5u
M$4 3 4 1 1 sg13_lv_pmos L=0.13u W=1.12u AS=0.2128p AD=0.3808p PS=1.5u PD=2.92u
.ENDS sg13g2_nand2_1

.SUBCKT sg13g2_or3_1 1 2 3 4 5 7
M$1 6 3 2 2 sg13_lv_nmos L=0.13u W=0.55u AS=0.187p AD=0.1045p PS=1.78u PD=0.93u
M$2 2 5 6 2 sg13_lv_nmos L=0.13u W=0.55u AS=0.1045p AD=0.198p PS=0.93u PD=1.27u
M$3 6 4 2 2 sg13_lv_nmos L=0.13u W=0.55u AS=0.198p AD=0.13395p PS=1.27u PD=1.12u
M$4 2 6 7 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.13395p AD=0.2516p PS=1.12u
+ PD=2.16u
M$5 6 3 9 1 sg13_lv_pmos L=0.13u W=1u AS=0.34p AD=0.1275p PS=2.68u PD=1.255u
M$6 9 5 8 1 sg13_lv_pmos L=0.13u W=1u AS=0.1275p AD=0.22p PS=1.255u PD=1.44u
M$7 8 4 1 1 sg13_lv_pmos L=0.13u W=1u AS=0.22p AD=0.3822p PS=1.44u PD=1.84u
M$8 1 6 7 1 sg13_lv_pmos L=0.13u W=1.12u AS=0.3822p AD=0.3808p PS=1.84u PD=2.92u
.ENDS sg13g2_or3_1

.SUBCKT sg13g2_tiehi 2 5 6
M$1 6 4 4 6 sg13_lv_nmos L=0.13u W=0.3u AS=0.2307p AD=0.102p PS=1.615u PD=1.28u
M$2 6 3 1 6 sg13_lv_nmos L=0.13u W=0.795u AS=0.2307p AD=0.274275p PS=1.615u
+ PD=2.28u
M$3 3 4 5 5 sg13_lv_pmos L=0.13u W=0.66u AS=0.2442p AD=0.4657125p PS=2.06u
+ PD=2.54u
M$4 5 1 2 5 sg13_lv_pmos L=0.13u W=1.155u AS=0.4657125p AD=0.3927p PS=2.54u
+ PD=2.99u
.ENDS sg13g2_tiehi

.SUBCKT freq_div_cell 1 2 3 4 5 7 8 10
X$1 1 6 9 2 7 10 half_add
X$2 3 9 11 6 7 8 10 dff_nclk
X$3 7 5 10 4 6 sg13g2_xor2_1
.ENDS freq_div_cell

.SUBCKT dff_nclk 1 2 3 4 6 7 8
X$1 8 6 1 5 sg13g2_inv_1
X$2 6 7 3 4 2 5 8 sg13g2_dfrbp_1
.ENDS dff_nclk

.SUBCKT half_add 1 2 3 4 5 6
X$1 5 3 6 2 1 sg13g2_xor2_1
X$2 6 5 4 1 2 sg13g2_and2_1
.ENDS half_add

.SUBCKT sg13g2_dfrbp_1 1 2 7 9 10 12 20
M$1 1 12 11 1 sg13_lv_nmos L=0.13u W=0.74u AS=0.1544p AD=0.2516p PS=1.235u
+ PD=2.16u
M$2 1 11 3 1 sg13_lv_nmos L=0.13u W=0.74u AS=0.1544p AD=0.2516p PS=1.235u
+ PD=2.16u
M$3 5 11 19 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.2017p AD=0.0546p PS=1.48u
+ PD=0.68u
M$4 19 6 1 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.0546p AD=0.0903p PS=0.68u
+ PD=0.85u
M$5 1 2 18 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.0903p AD=0.04725p PS=0.85u
+ PD=0.645u
M$6 18 5 6 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.04725p AD=0.1428p PS=0.645u
+ PD=1.52u
M$7 1 13 14 1 sg13_lv_nmos L=0.13u W=0.64u AS=0.1825p AD=0.193975p PS=1.325u
+ PD=1.29u
M$8 14 3 5 1 sg13_lv_nmos L=0.13u W=0.64u AS=0.193975p AD=0.2017p PS=1.29u
+ PD=1.48u
M$9 4 11 13 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.1428p AD=0.0798p PS=1.52u
+ PD=0.8u
M$10 13 3 16 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.0798p AD=0.0546p PS=0.8u
+ PD=0.68u
M$11 16 14 17 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.0546p AD=0.0483p PS=0.68u
+ PD=0.65u
M$12 1 2 17 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.1825p AD=0.0483p PS=1.325u
+ PD=0.65u
M$13 1 5 7 1 sg13_lv_nmos L=0.13u W=0.74u AS=0.2516p AD=0.2775p PS=2.16u
+ PD=2.23u
M$14 8 5 1 1 sg13_lv_nmos L=0.13u W=0.55u AS=0.187p AD=0.14505p PS=1.78u
+ PD=1.15u
M$15 1 8 9 1 sg13_lv_nmos L=0.13u W=0.74u AS=0.14505p AD=0.2516p PS=1.15u
+ PD=2.16u
M$16 4 10 15 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.1428p AD=0.0504p PS=1.52u
+ PD=0.66u
M$17 15 2 1 1 sg13_lv_nmos L=0.13u W=0.42u AS=0.0504p AD=0.1428p PS=0.66u
+ PD=1.52u
M$18 20 5 8 20 sg13_lv_pmos L=0.13u W=0.84u AS=0.2016p AD=0.2856p PS=1.5u
+ PD=2.36u
M$19 20 8 9 20 sg13_lv_pmos L=0.13u W=1.12u AS=0.2016p AD=0.3808p PS=1.5u
+ PD=2.92u
M$20 11 12 20 20 sg13_lv_pmos L=0.13u W=1u AS=0.34p AD=0.19p PS=2.68u PD=1.38u
M$21 20 11 3 20 sg13_lv_pmos L=0.13u W=1u AS=0.19p AD=0.34p PS=1.38u PD=2.68u
M$22 20 13 14 20 sg13_lv_pmos L=0.13u W=1u AS=0.34p AD=0.19p PS=2.68u PD=1.38u
M$23 14 11 5 20 sg13_lv_pmos L=0.13u W=1u AS=0.19p AD=0.17695p PS=1.38u PD=1.56u
M$24 5 3 22 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.17695p AD=0.04305p PS=1.56u
+ PD=0.625u
M$25 22 6 20 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.04305p AD=0.0798p PS=0.625u
+ PD=0.8u
M$26 20 2 6 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.0798p AD=0.0798p PS=0.8u
+ PD=0.8u
M$27 20 5 6 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.2163p AD=0.0798p PS=1.55u
+ PD=0.8u
M$28 20 5 7 20 sg13_lv_pmos L=0.13u W=1.12u AS=0.2163p AD=0.7616p PS=1.55u
+ PD=3.6u
M$29 4 3 13 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.1428p AD=0.0798p PS=1.52u
+ PD=0.8u
M$30 13 11 21 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.0798p AD=0.05145p PS=0.8u
+ PD=0.665u
M$31 21 14 20 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.05145p AD=0.11785p PS=0.665u
+ PD=1.025u
M$32 20 2 13 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.11785p AD=0.1533p PS=1.025u
+ PD=1.57u
M$33 20 10 4 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.1428p AD=0.0798p PS=1.52u
+ PD=0.8u
M$34 4 2 20 20 sg13_lv_pmos L=0.13u W=0.42u AS=0.0798p AD=0.1428p PS=0.8u
+ PD=1.52u
.ENDS sg13g2_dfrbp_1

.SUBCKT sg13g2_inv_1 1 2 3 4
M$1 2 3 4 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.259p AD=0.259p PS=2.18u PD=2.18u
M$2 1 3 4 1 sg13_lv_pmos L=0.13u W=1.12u AS=0.392p AD=0.392p PS=2.94u PD=2.94u
.ENDS sg13g2_inv_1

.SUBCKT sg13g2_and2_1 1 2 3 4 5
M$1 6 4 7 2 sg13_lv_nmos L=0.13u W=0.64u AS=0.2176p AD=0.1216p PS=1.96u PD=1.02u
M$2 2 5 7 2 sg13_lv_nmos L=0.13u W=0.64u AS=0.1331p AD=0.1216p PS=1.12u PD=1.02u
M$3 2 6 3 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.1331p AD=0.2516p PS=1.12u PD=2.16u
M$4 1 4 6 1 sg13_lv_pmos L=0.13u W=0.84u AS=0.2856p AD=0.1596p PS=2.36u PD=1.22u
M$5 1 5 6 1 sg13_lv_pmos L=0.13u W=0.84u AS=0.1918p AD=0.1596p PS=1.5u PD=1.22u
M$6 1 6 3 1 sg13_lv_pmos L=0.13u W=1.12u AS=0.1918p AD=0.3808p PS=1.5u PD=2.92u
.ENDS sg13g2_and2_1

.SUBCKT sg13g2_xor2_1 2 4 5 6 7
M$1 2 7 1 2 sg13_lv_nmos L=0.13u W=0.55u AS=0.374p AD=0.174625p PS=2.46u
+ PD=1.185u
M$2 2 6 1 2 sg13_lv_nmos L=0.13u W=0.55u AS=0.15245p AD=0.174625p PS=1.17u
+ PD=1.185u
M$3 2 7 8 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.15245p AD=0.0888p PS=1.17u
+ PD=0.98u
M$4 8 6 4 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.0888p AD=0.1628p PS=0.98u PD=1.18u
M$5 4 1 2 2 sg13_lv_nmos L=0.13u W=0.74u AS=0.1628p AD=0.3108p PS=1.18u PD=2.32u
M$6 3 7 5 5 sg13_lv_pmos L=0.13u W=1.12u AS=0.3808p AD=0.2128p PS=2.92u PD=1.5u
M$7 5 6 3 5 sg13_lv_pmos L=0.13u W=1.12u AS=0.2128p AD=0.2128p PS=1.5u PD=1.5u
M$8 3 1 4 5 sg13_lv_pmos L=0.13u W=1.12u AS=0.2128p AD=0.3808p PS=1.5u PD=2.92u
M$9 5 7 9 5 sg13_lv_pmos L=0.13u W=1u AS=0.36p AD=0.1225p PS=2.72u PD=1.245u
M$10 9 6 1 5 sg13_lv_pmos L=0.13u W=1u AS=0.1225p AD=0.34p PS=1.245u PD=2.68u
.ENDS sg13g2_xor2_1

# Layout, gdstk code
from math import pi, radians
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
Activ = (1, 0)
GatPoly = (5, 0)
Cont = (6, 0)
Metal1 = (8, 0)
Metal1_pin = (8, 2)
Metal2 = (10, 0)
Metal2_pin = (10, 2)
pSD = (14, 0)
Via1 = (19, 0)
Via2 = (29, 0)
Metal3 = (30, 0)
Metal3_pin = (30, 2)
NWell = (31, 0)
boundary = (189, 4)

sg13g2_xor2_1 = lib.new_cell('sg13g2_xor2_1')
R(sg13g2_xor2_1, Activ, [(0,-0.15,3.84,0.15), (1.9,2.06,3.73,3.18), (0.395,2.18,1.6,3.18), (0,3.63,3.84,3.93)])
P(sg13g2_xor2_1, Activ, [(1.88,0.65),(1.88,0.84),(0.235,0.84),(0.235,1.39),(3.73,1.39),(3.73,0.65)])
R(sg13g2_xor2_1, GatPoly, [(3.12,1.535,3.345,1.865)])
P(sg13g2_xor2_1, GatPoly, [(2.61,0.47),(2.61,1.895),(2.75,1.895),(2.75,3.365),(2.88,3.365),(2.88,1.98),(2.94,1.98),(2.94,1.565),(2.74,1.565),(2.74,0.47)],
  [(3.18,0.47),(3.18,1.865),(3.26,1.865),(3.26,3.365),(3.39,3.365),(3.39,1.865),(3.45,1.865),(3.45,1.535),(3.31,1.535),(3.31,0.47)],
  [(1.68,0.66),(1.68,1.58),(1.38,1.58),(1.38,1.91),(1.13,1.91),(1.13,3.365),(1.26,3.365),(1.26,2.06),(1.81,2.06),(1.81,0.66)],
  [(0.915,0.32),(0.915,1.5),(0.2,1.5),(0.2,1.83),(0.755,1.83),(0.755,3.365),(0.885,3.365),(0.885,1.65),(1.045,1.65),(1.045,0.47),(2.24,0.47),(2.24,1.465),(2.19,1.465),(2.19,1.98),(2.24,1.98),(2.24,3.365),(2.37,3.365),(2.37,0.32)])
A(sg13g2_xor2_1, Cont, 0.16, -0.08, 0.16, 0.16, 8, 2, 0.48, 3.78)
A(sg13g2_xor2_1, Cont, 1.97, 2.945, 0.16, 0.16, 4, 1, 0.51, 0)
R(sg13g2_xor2_1, Cont, [(1.95,0.725,2.11,0.885), (2.885,0.725,3.045,0.885), (3.42,0.725,3.58,0.885), (0.305,0.96,0.465,1.12), (0.645,0.96,0.805,1.12), (1.155,1.01,1.315,1.17), (2.885,1.12,3.045,1.28), (1.95,1.16,2.11,1.32), (0.27,1.585,0.43,1.745), (0.61,1.585,0.77,1.745), (3.19,1.62,3.35,1.78), (2.68,1.65,2.84,1.81), (1.55,1.665,1.71,1.825), (3.5,2.22,3.66,2.38), (0.485,2.25,0.645,2.41), (1.37,2.25,1.53,2.41), (1.97,2.59,2.13,2.75), (2.99,2.59,3.15,2.75), (0.485,2.595,0.645,2.755), (3.5,2.595,3.66,2.755), (1.37,2.6,1.53,2.76), (0.485,2.945,0.645,3.105), (1.37,2.945,1.53,3.105)])
R(sg13g2_xor2_1, Metal1, [(0.145,1.45,0.82,1.915), (1.475,1.535,2.93,1.87)])
P(sg13g2_xor2_1, Metal1, [(1.92,2.52),(1.92,3.155),(2.18,3.155),(2.18,2.68),(2.94,2.68),(2.94,3.16),(3.2,3.16),(3.2,2.52)],
  [(0.435,2.23),(0.435,3.56),(0,3.56),(0,4),(3.84,4),(3.84,3.56),(2.69,3.56),(2.69,2.895),(2.43,2.895),(2.43,3.56),(0.695,3.56),(0.695,2.23)],
  [(1.03,0.93),(1.03,3.155),(1.55,3.155),(1.55,2.34),(3.27,2.34),(3.27,1.87),(3.35,1.87),(3.35,1.54),(3.11,1.54),(3.11,2.17),(1.2,2.17),(1.2,1.26),(1.4,1.26),(1.4,0.93)],
  [(0,-0.22),(0,0.22),(0.285,0.22),(0.285,1.18),(0.82,1.18),(0.82,0.22),(1.9,0.22),(1.9,1.34),(2.16,1.34),(2.16,0.22),(3.37,0.22),(3.37,0.905),(3.63,0.905),(3.63,0.22),(3.84,0.22),(3.84,-0.22)],
  [(2.835,0.67),(2.835,1.315),(3.53,1.315),(3.53,2.155),(3.45,2.155),(3.45,3.16),(3.71,3.16),(3.71,1.105),(3.1,1.105),(3.1,0.67)])
R(sg13g2_xor2_1, Metal1_pin, [(0,-0.22,3.84,0.22), (0.145,1.45,0.82,1.915), (1.475,1.535,2.93,1.87), (3.45,2.155,3.71,3.16), (0,3.56,3.84,4)])
R(sg13g2_xor2_1, pSD, [(-0.07,-0.18,3.91,0.18), (-0.07,1.76,3.91,3.6)])
R(sg13g2_xor2_1, NWell, [(-0.24,1.75,4.08,4.17)])
R(sg13g2_xor2_1, boundary, [(0,0,3.84,3.78)])
sg13g2_xor2_1.add(gdstk.Label('X', (3.505,2.635), layer=8, texttype=25))
sg13g2_xor2_1.add(gdstk.Label('VDD', (2.3,3.775), layer=8, texttype=25))
sg13g2_xor2_1.add(gdstk.Label('B', (2.255,1.725), layer=8, texttype=25))
sg13g2_xor2_1.add(gdstk.Label('A', (0.52,1.63), layer=8, texttype=25))
sg13g2_xor2_1.add(gdstk.Label('VSS', (2.09,0.02), layer=8, texttype=25))

sg13g2_and2_1 = lib.new_cell('sg13g2_and2_1')
R(sg13g2_and2_1, Activ, [(0,-0.15,2.4,0.15), (0,3.63,2.4,3.93)])
P(sg13g2_and2_1, Activ, [(1.355,0.7),(1.355,0.8),(0.225,0.8),(0.225,1.44),(2.055,1.44),(2.055,0.7)],
  [(1.355,2.06),(1.355,2.34),(0.225,2.34),(0.225,3.18),(2.055,3.18),(2.055,2.06)])
P(sg13g2_and2_1, GatPoly, [(1.585,0.52),(1.585,1.57),(1.385,1.57),(1.385,1.9),(1.585,1.9),(1.585,3.36),(1.715,3.36),(1.715,1.9),(1.775,1.9),(1.775,1.57),(1.715,1.57),(1.715,0.52)],
  [(0.105,0.41),(0.105,0.73),(0.565,0.73),(0.565,3.36),(0.695,3.36),(0.695,0.73),(0.775,0.73),(0.775,0.41)],
  [(1.075,0.62),(1.075,1.57),(0.875,1.57),(0.875,1.9),(1.075,1.9),(1.075,3.36),(1.205,3.36),(1.205,0.62)])
A(sg13g2_and2_1, Cont, 0.16, -0.08, 0.16, 0.16, 5, 1, 0.48, 0)
A(sg13g2_and2_1, Cont, 0.295, 2.94, 0.16, 0.16, 4, 1, 0.51, 0)
R(sg13g2_and2_1, Cont, [(0.19,0.48,0.35,0.64), (0.53,0.48,0.69,0.64), (1.825,0.795,1.985,0.955), (1.315,0.985,1.475,1.145), (0.295,1.18,0.455,1.34), (1.825,1.185,1.985,1.345), (0.96,1.655,1.12,1.815), (1.53,1.655,1.69,1.815), (1.825,2.155,1.985,2.315), (0.295,2.435,0.455,2.595), (0.805,2.435,0.965,2.595), (1.315,2.495,1.475,2.655), (1.825,2.555,1.985,2.715), (0.16,3.7,0.32,3.86), (0.16,3.7,0.32,3.86), (0.16,3.7,0.32,3.86), (0.64,3.7,0.8,3.86), (0.64,3.7,0.8,3.86), (1.12,3.7,1.28,3.86), (1.12,3.7,1.28,3.86), (1.6,3.7,1.76,3.86), (1.6,3.7,1.76,3.86), (2.08,3.7,2.24,3.86), (2.08,3.7,2.24,3.86)])
R(sg13g2_and2_1, Metal1, [(0.105,0.405,0.78,0.96), (0.78,1.435,1.17,1.87)])
P(sg13g2_and2_1, Metal1, [(0.245,1.14),(0.245,2.24),(0.755,2.24),(0.755,3.11),(1.015,3.11),(1.015,2.24),(1.56,2.24),(1.56,1.9),(1.74,1.9),(1.74,1.57),(1.4,1.57),(1.4,2.05),(0.505,2.05),(0.505,1.14)],
  [(1.775,0.78),(1.775,1.36),(2.04,1.36),(2.04,2.14),(1.775,2.14),(1.775,3.11),(2.275,3.11),(2.275,0.78)],
  [(0.245,2.425),(0.245,3.56),(0,3.56),(0,4),(2.4,4),(2.4,3.56),(1.525,3.56),(1.525,2.485),(1.265,2.485),(1.265,3.56),(0.505,3.56),(0.505,2.425)],
  [(0,-0.22),(0,0.22),(1.265,0.22),(1.265,1.155),(1.525,1.155),(1.525,0.22),(2.4,0.22),(2.4,-0.22)])
R(sg13g2_and2_1, Metal1_pin, [(0,-0.22,2.4,0.22), (0.105,0.405,0.78,0.96), (0.78,1.435,1.17,1.87), (1.775,2.14,2.275,3.11), (0,3.56,2.4,4)])
R(sg13g2_and2_1, pSD, [(-0.07,-0.18,2.47,0.18), (-0.07,1.76,0.55,3.6), (-0.07,1.76,2.47,3.6)])
R(sg13g2_and2_1, NWell, [(-0.24,1.75,2.64,4.17)])
R(sg13g2_and2_1, boundary, [(0,0,2.4,3.78)])
sg13g2_and2_1.add(gdstk.Label('X', (1.995,2.68), layer=8, texttype=25))
sg13g2_and2_1.add(gdstk.Label('VSS', (1.18,0), layer=8, texttype=25))
sg13g2_and2_1.add(gdstk.Label('VDD', (1.275,3.78), layer=8, texttype=25))
sg13g2_and2_1.add(gdstk.Label('B', (0.98,1.655), layer=8, texttype=25))
sg13g2_and2_1.add(gdstk.Label('A', (0.465,0.745), layer=8, texttype=25))

half_add = lib.new_cell('half_add')
R(half_add, Activ, [(-1.24,-1.02,-0.76,-0.72), (-1.24,2.76,-0.76,3.06)])
R(half_add, Metal1, [(-1.24,-1.09,-0.76,-0.65), (-1.24,2.69,-0.76,3.13)])
P(half_add, Metal2, [(-3.64,1.95),(-3.64,2.505),(-2.86,2.505),(-2.86,2.24),(-1.47,2.24),(-1.47,1.95)],
  [(1.295,-0.465),(1.295,1.31),(-2.52,1.31),(-2.52,0.64),(-2.81,0.64),(-2.81,1.6),(1.585,1.6),(1.585,-0.04),(2.3,-0.04),(2.3,0.09),(3.08,0.09),(3.08,-0.465)],
  [(-3.64,-0.465),(-3.64,0.09),(-0.42,0.09),(-0.42,0.96),(-0.13,0.96),(-0.13,-0.34),(-2.86,-0.34),(-2.86,-0.465)],
  [(2.675,1.64),(2.675,1.95),(2.3,1.95),(2.3,2.505),(3.08,2.505),(3.08,1.64)])
R(half_add, Metal2_pin, [(-3.64,-0.465,-2.86,0.09), (2.3,-0.465,3.08,0.09), (-3.64,1.95,-2.86,2.505), (2.3,1.95,3.08,2.505)])
R(half_add, pSD, [(-1.17,-1.05,-0.83,-0.69), (-1.17,0.89,-0.83,2.73)])
R(half_add, Via1, [(-3.295,-0.285,-3.105,-0.095), (-2.76,0.69,-2.57,0.88), (-0.37,0.72,-0.18,0.91), (1.345,0.735,1.535,0.925), (2.725,1.695,2.915,1.885), (-1.71,2,-1.52,2.19)])
half_add.add(gdstk.Reference(sg13g2_xor2_1, (-0.76,-0.87)))
half_add.add(gdstk.Reference(sg13g2_and2_1, (-3.64,-0.87)))
half_add.add(gdstk.Label('inA', (-3.25,-0.187), layer=10, texttype=25))
half_add.add(gdstk.Label('inB', (2.69,-0.187), layer=10, texttype=25))
half_add.add(gdstk.Label('sum', (2.69,2.228), layer=10, texttype=25))
half_add.add(gdstk.Label('cout', (-3.25,2.228), layer=10, texttype=25))

sg13g2_inv_1 = lib.new_cell('sg13g2_inv_1')
R(sg13g2_inv_1, Activ, [(0,-0.15,1.44,0.15), (0.475,0.59,1.305,1.33), (0.485,2.075,1.315,3.195), (0,3.63,1.44,3.93)])
P(sg13g2_inv_1, GatPoly, [(0.825,0.41),(0.825,1.52),(0.145,1.52),(0.145,1.85),(0.835,1.85),(0.835,3.375),(0.965,3.375),(0.965,1.52),(0.955,1.52),(0.955,0.41)])
A(sg13g2_inv_1, Cont, 0.56, 2.235, 0.16, 0.16, 1, 3, 0, 0.35)
R(sg13g2_inv_1, Cont, [(0.16,-0.08,0.32,0.08), (0.16,-0.08,0.32,0.08), (0.64,-0.08,0.8,0.08), (0.64,-0.08,0.8,0.08), (1.12,-0.08,1.28,0.08), (1.12,-0.08,1.28,0.08), (0.55,0.67,0.71,0.83), (1.07,0.67,1.23,0.83), (0.55,1.095,0.71,1.255), (1.07,1.095,1.23,1.255), (0.23,1.605,0.39,1.765), (0.585,1.605,0.745,1.765), (1.08,2.155,1.24,2.315), (1.08,2.54,1.24,2.7), (1.075,2.93,1.235,3.09), (0.16,3.7,0.32,3.86), (0.16,3.7,0.32,3.86), (0.64,3.7,0.8,3.86), (0.64,3.7,0.8,3.86), (1.12,3.7,1.28,3.86), (1.12,3.7,1.28,3.86)])
R(sg13g2_inv_1, Metal1, [(1.045,0.595,1.275,3.175), (0.125,1.52,0.815,2)])
P(sg13g2_inv_1, Metal1, [(0,-0.22),(0,0.22),(0.485,0.22),(0.485,1.295),(0.785,1.295),(0.785,0.22),(1.44,0.22),(1.44,-0.22)],
  [(0.505,2.205),(0.505,3.56),(0,3.56),(0,4),(1.44,4),(1.44,3.56),(0.78,3.56),(0.78,2.205)])
R(sg13g2_inv_1, Metal1_pin, [(0,-0.22,1.44,0.22), (1.045,0.595,1.275,3.175), (0.125,1.52,0.815,2), (0,3.56,1.44,4)])
R(sg13g2_inv_1, pSD, [(-0.07,-0.18,1.51,0.18), (-0.07,1.76,1.51,3.6)])
R(sg13g2_inv_1, NWell, [(-0.24,1.75,1.68,4.17)])
R(sg13g2_inv_1, boundary, [(0,0,1.44,3.78)])
sg13g2_inv_1.add(gdstk.Label('Y', (1.17,1.69), layer=8, texttype=25))
sg13g2_inv_1.add(gdstk.Label('A', (0.485,1.76), layer=8, texttype=25))
sg13g2_inv_1.add(gdstk.Label('VSS', (0.72,-0.02), layer=8, texttype=25))
sg13g2_inv_1.add(gdstk.Label('VDD', (0.705,3.78), layer=8, texttype=25))

sg13g2_dfrbp_1 = lib.new_cell('sg13g2_dfrbp_1')
R(sg13g2_dfrbp_1, Activ, [(0,-0.15,12.48,0.15), (9.525,0.59,10.37,1.33), (0.38,0.61,1.56,1.03), (1.865,2.18,3.185,3.18), (0.335,2.76,1.655,3.18), (0,3.63,12.48,3.93)])
P(sg13g2_dfrbp_1, Activ, [(10.725,0.59),(10.725,1.14),(11.265,1.14),(11.265,1.33),(12.075,1.33),(12.075,0.59)],
  [(11.275,2.06),(11.275,2.34),(10.725,2.34),(10.725,3.18),(12.045,3.18),(12.045,2.06)],
  [(6.175,1.955),(6.175,2.955),(7.41,2.955),(7.41,2.995),(9.23,2.995),(9.23,3.18),(10.4,3.18),(10.4,2.06),(9.23,2.06),(9.23,2.575),(7.39,2.575),(7.39,1.955)],
  [(5.46,0.395),(5.46,0.81),(3.66,0.81),(3.66,1.23),(5.71,1.23),(5.71,1.225),(6.095,1.225),(6.095,1.335),(6.48,1.335),(6.48,1.225),(6.91,1.225),(6.91,1.005),(9.295,1.005),(9.295,0.585),(5.805,0.585),(5.805,0.395)],
  [(3.535,2.535),(3.535,2.955),(4.96,2.955),(4.96,3.115),(5.265,3.115),(5.265,2.955),(5.83,2.955),(5.83,2.535)],
  [(2.435,0.65),(2.435,0.765),(1.895,0.765),(1.895,1.505),(3.215,1.505),(3.215,0.765),(2.675,0.765),(2.675,0.65)])
P(sg13g2_dfrbp_1, GatPoly, [(11.605,0.41),(11.605,1.52),(11.44,1.52),(11.44,1.85),(11.575,1.85),(11.575,3.36),(11.705,3.36),(11.705,1.85),(11.77,1.85),(11.77,1.52),(11.735,1.52),(11.735,0.41)],
  [(8.825,0.405),(8.825,1.53),(8.83,1.53),(8.83,1.815),(9.03,1.815),(9.03,3.175),(9.16,3.175),(9.16,1.815),(9.59,1.815),(9.59,3.36),(9.72,3.36),(9.72,1.815),(11.065,1.815),(11.065,3.36),(11.195,3.36),(11.195,0.41),(11.065,0.41),(11.065,1.485),(9.995,1.485),(9.995,0.41),(9.865,0.41),(9.865,1.485),(8.955,1.485),(8.955,0.405)],
  [(8.47,0.405),(8.47,2.055),(8.445,2.055),(8.445,2.385),(8.52,2.385),(8.52,3.175),(8.65,3.175),(8.65,2.385),(8.8,2.385),(8.8,2.055),(8.6,2.055),(8.6,0.405)],
  [(7.91,0.405),(7.91,1.45),(8.08,1.45),(8.08,2.22),(8.01,2.22),(8.01,3.175),(8.14,3.175),(8.14,2.39),(8.21,2.39),(8.21,1.45),(8.26,1.45),(8.26,1.12),(8.04,1.12),(8.04,0.405)],
  [(7.485,2.085),(7.485,2.395),(7.675,2.395),(7.675,3.175),(7.805,3.175),(7.805,2.395),(7.83,2.395),(7.83,2.085)],
  [(7.52,0.405),(7.52,1.695),(7.025,1.695),(7.025,3.225),(6.95,3.225),(6.95,3.315),(4.515,3.315),(4.515,2.355),(4.385,2.355),(4.385,3.315),(3.385,3.315),(3.385,1.79),(3.53,1.79),(3.53,1.78),(3.54,1.78),(3.54,1.77),(3.55,1.77),(3.55,1.76),(3.56,1.76),(3.56,1.75),(3.57,1.75),(3.57,1.74),(3.58,1.74),(3.58,1.73),(3.59,1.73),(3.59,1.72),(3.6,1.72),(3.6,1.71),(3.61,1.71),(3.61,1.7),(3.62,1.7),(3.62,1.69),(3.63,1.69),(3.63,1.68),(3.645,1.68),(3.645,1.57),(4.13,1.57),(4.13,0.63),(4,0.63),(4,1.42),(3.495,1.42),(3.495,1.6),(3.485,1.6),(3.485,1.61),(3.475,1.61),(3.475,1.62),(3.46,1.62),(3.46,1.625),(2.875,1.625),(2.875,0.585),(2.745,0.585),(2.745,1.63),(2.715,1.63),(2.715,3.36),(2.845,3.36),(2.845,1.995),(3.255,1.995),(3.255,3.445),(7.155,3.445),(7.155,1.845),(7.65,1.845),(7.65,0.405)],
  [(6.55,0.405),(6.55,1.455),(7.31,1.455),(7.31,1.12),(6.98,1.12),(6.98,1.305),(6.68,1.305),(6.68,0.405)],
  [(5.88,0.405),(5.88,1.505),(5.73,1.505),(5.73,1.835),(6.5,1.835),(6.5,1.88),(6.515,1.88),(6.515,3.135),(6.645,3.135),(6.645,1.88),(6.68,1.88),(6.68,1.685),(6.06,1.685),(6.06,1.505),(6.01,1.505),(6.01,0.405)],
  [(1.09,0.235),(1.09,2.685),(1.185,2.685),(1.185,3.36),(1.315,3.36),(1.315,2.685),(1.35,2.685),(1.35,2.36),(1.555,2.36),(1.555,1.35),(1.22,1.35),(1.22,0.365),(5.26,0.365),(5.26,1.46),(5.31,1.46),(5.31,2.46),(5.335,2.46),(5.335,3.135),(5.465,3.135),(5.465,2.46),(5.49,2.46),(5.49,2.375),(6.04,2.375),(6.04,2.045),(5.46,2.045),(5.46,1.31),(5.39,1.31),(5.39,0.235)],
  [(4.9,0.63),(4.9,1.705),(4.8,1.705),(4.8,2.225),(4.76,2.225),(4.76,3.135),(4.89,3.135),(4.89,2.375),(5.13,2.375),(5.13,1.705),(5.03,1.705),(5.03,0.63)],
  [(4.51,0.63),(4.51,1.31),(4.44,1.31),(4.44,1.78),(3.84,1.78),(3.84,1.795),(3.83,1.795),(3.83,1.805),(3.82,1.805),(3.82,1.815),(3.81,1.815),(3.81,1.825),(3.8,1.825),(3.8,1.835),(3.79,1.835),(3.79,1.845),(3.78,1.845),(3.78,1.855),(3.77,1.855),(3.77,1.865),(3.76,1.865),(3.76,1.875),(3.75,1.875),(3.75,1.885),(3.74,1.885),(3.74,1.895),(3.73,1.895),(3.73,1.905),(3.72,1.905),(3.72,2.205),(3.875,2.205),(3.875,3.135),(4.005,3.135),(4.005,2.43),(4.05,2.43),(4.05,1.93),(4.59,1.93),(4.59,1.46),(4.64,1.46),(4.64,0.63)],
  [(2.235,0.585),(2.235,1.63),(2.125,1.63),(2.125,1.995),(2.205,1.995),(2.205,3.36),(2.335,3.36),(2.335,1.995),(2.48,1.995),(2.48,1.63),(2.365,1.63),(2.365,0.585)],
  [(0.72,0.43),(0.72,1.22),(0.445,1.22),(0.445,2.57),(0.64,2.57),(0.64,2.685),(0.675,2.685),(0.675,3.36),(0.805,3.36),(0.805,2.685),(0.82,2.685),(0.82,2.57),(0.85,2.57),(0.85,0.43)])
A(sg13g2_dfrbp_1, Cont, 0.16, -0.08, 0.16, 0.16, 26, 2, 0.48, 3.78)
A(sg13g2_dfrbp_1, Cont, 0.525, 1.3, 0.16, 0.16, 1, 3, 0, 0.34)
A(sg13g2_dfrbp_1, Cont, 1.305, 1.43, 0.16, 0.16, 1, 3, 0, 0.34)
R(sg13g2_dfrbp_1, Cont, [(5.53,0.47,5.69,0.63), (9.595,0.66,9.755,0.82), (10.14,0.66,10.3,0.82), (11.845,0.66,12.005,0.82), (11.335,0.665,11.495,0.825), (8.18,0.69,8.34,0.85), (7.21,0.7,7.37,0.86), (9.065,0.715,9.225,0.875), (0.45,0.735,0.61,0.895), (1.33,0.735,1.49,0.895), (10.795,0.775,10.955,0.935), (2.475,0.825,2.635,0.985), (2.985,0.835,3.145,0.995), (6.28,0.93,6.44,1.09), (3.73,0.945,3.89,1.105), (4.24,0.945,4.4,1.105), (1.965,1,2.125,1.16), (10.14,1.1,10.3,1.26), (11.335,1.1,11.495,1.26), (11.845,1.1,12.005,1.26), (7.06,1.2,7.22,1.36), (8.01,1.2,8.17,1.36), (8.91,1.565,9.07,1.725), (5.81,1.585,5.97,1.745), (11.52,1.6,11.68,1.76), (2.895,1.695,3.055,1.855), (2.23,1.745,2.39,1.905), (4.88,1.785,5.04,1.945), (3.8,1.955,3.96,2.115), (6.755,2.025,6.915,2.185), (6.245,2.04,6.405,2.2), (4.88,2.125,5.04,2.285), (5.81,2.125,5.97,2.285), (9.83,2.13,9.99,2.29), (10.17,2.13,10.33,2.29), (11.815,2.13,11.975,2.29), (8.515,2.135,8.675,2.295), (7.555,2.165,7.715,2.325), (1.935,2.25,2.095,2.41), (2.955,2.25,3.115,2.41), (6.755,2.37,6.915,2.53), (6.245,2.38,6.405,2.54), (9.3,2.405,9.46,2.565), (10.795,2.41,10.955,2.57), (9.83,2.535,9.99,2.695), (10.17,2.535,10.33,2.695), (11.305,2.535,11.465,2.695), (11.815,2.535,11.975,2.695), (5.595,2.65,5.755,2.81), (3.605,2.66,3.765,2.82), (7.305,2.665,7.465,2.825), (8.25,2.7,8.41,2.86), (8.76,2.7,8.92,2.86), (4.115,2.725,4.275,2.885), (6.245,2.725,6.405,2.885), (6.755,2.725,6.915,2.885), (0.405,2.885,0.565,3.045), (0.915,2.885,1.075,3.045), (5.03,2.885,5.19,3.045), (9.3,2.885,9.46,3.045), (2.445,2.94,2.605,3.1), (10.795,2.945,10.955,3.105), (1.425,2.95,1.585,3.11), (9.83,2.95,9.99,3.11), (10.17,2.95,10.33,3.11), (11.305,2.95,11.465,3.11), (11.815,2.95,11.975,3.11)])
R(sg13g2_dfrbp_1, Metal1, [(0.44,1.22,0.735,2.415), (1.255,1.35,1.525,2.36), (5.615,2.045,6.015,2.355), (8.325,2.055,8.725,2.385)])
P(sg13g2_dfrbp_1, Metal1, [(2.045,1.575),(2.045,1.915),(2.27,1.915),(2.27,1.985),(2.49,1.985),(2.49,1.575)],
  [(0,-0.22),(0,0.22),(1.28,0.22),(1.28,0.91),(1.54,0.91),(1.54,0.22),(2.425,0.22),(2.425,1.02),(2.685,1.02),(2.685,0.22),(5.48,0.22),(5.48,0.63),(5.74,0.63),(5.74,0.22),(8.13,0.22),(8.13,0.875),(8.39,0.875),(8.39,0.22),(9.545,0.22),(9.545,0.86),(9.805,0.86),(9.805,0.22),(11.285,0.22),(11.285,1.27),(11.545,1.27),(11.545,0.22),(12.48,0.22),(12.48,-0.22)],
  [(6.235,1.99),(6.235,3.56),(5.24,3.56),(5.24,2.875),(4.98,2.875),(4.98,3.56),(2.655,3.56),(2.655,2.94),(2.395,2.94),(2.395,3.56),(1.635,3.56),(1.635,2.935),(1.375,2.935),(1.375,3.56),(0.615,3.56),(0.615,2.86),(0.355,2.86),(0.355,3.56),(0,3.56),(0,4),(12.48,4),(12.48,3.56),(11.515,3.56),(11.515,2.52),(11.255,2.52),(11.255,3.56),(9.51,3.56),(9.51,2.395),(9.25,2.395),(9.25,3.56),(8.415,3.56),(8.415,2.65),(8.245,2.65),(8.245,3.56),(6.415,3.56),(6.415,1.99)],
  [(11.775,0.645),(11.775,1.28),(11.975,1.28),(11.975,2.08),(11.785,2.08),(11.785,3.16),(12.145,3.16),(12.145,0.645)],
  [(10.745,0.705),(10.745,3.135),(11.005,3.135),(11.005,1.85),(11.77,1.85),(11.77,1.52),(11.01,1.52),(11.01,0.705)],
  [(10.09,0.605),(10.09,2.08),(9.79,2.08),(9.79,3.165),(10.38,3.165),(10.38,2.08),(10.35,2.08),(10.35,0.605)],
  [(9.015,0.665),(9.015,1.12),(7.96,1.12),(7.96,1.375),(8.22,1.375),(8.22,1.29),(9.435,1.29),(9.435,1.995),(8.905,1.995),(8.905,2.645),(8.71,2.645),(8.71,2.91),(9.065,2.91),(9.065,2.155),(9.6,2.155),(9.6,1.12),(9.275,1.12),(9.275,0.665)],
  [(7.16,0.67),(7.16,0.885),(7.6,0.885),(7.6,1.815),(7.905,1.815),(7.905,2.615),(7.255,2.615),(7.255,2.875),(8.065,2.875),(8.065,1.815),(9.12,1.815),(9.12,1.5),(8.85,1.5),(8.85,1.645),(7.77,1.645),(7.77,0.67)],
  [(3.25,0.475),(3.25,0.765),(2.92,0.765),(2.92,1.055),(3.25,1.055),(3.25,1.47),(3.37,1.47),(3.37,2.045),(3.14,2.045),(3.14,2.085),(2.905,2.085),(2.905,2.415),(3.165,2.415),(3.165,2.3),(3.225,2.3),(3.225,2.285),(3.245,2.285),(3.245,2.28),(3.25,2.28),(3.25,2.26),(3.275,2.26),(3.275,2.215),(3.515,2.215),(3.515,2.17),(4,2.17),(4,1.875),(3.53,1.875),(3.53,1.31),(3.415,1.31),(3.415,0.635),(5.005,0.635),(5.005,0.97),(6.08,0.97),(6.08,0.695),(6.795,0.695),(6.795,1.45),(7.14,1.45),(7.14,2.415),(7.725,2.415),(7.725,2.085),(7.3,2.085),(7.3,1.12),(6.965,1.12),(6.965,0.53),(5.92,0.53),(5.92,0.81),(5.19,0.81),(5.19,0.475)],
  [(6.265,0.88),(6.265,1.15),(4.86,1.15),(4.86,2.345),(5.095,2.345),(5.095,1.31),(6.215,1.31),(6.215,1.79),(6.745,1.79),(6.745,2.935),(6.925,2.935),(6.925,1.63),(6.48,1.63),(6.48,0.88)],
  [(4.195,0.89),(4.195,1.175),(4.52,1.175),(4.52,2.7),(4.045,2.7),(4.045,2.915),(4.68,2.915),(4.68,2.695),(5.525,2.695),(5.525,2.86),(5.785,2.86),(5.785,2.535),(5.435,2.535),(5.435,1.835),(6.03,1.835),(6.03,1.505),(5.74,1.505),(5.74,1.665),(5.275,1.665),(5.275,2.535),(4.68,2.535),(4.68,0.89)],
  [(0.4,0.685),(0.4,0.95),(0.915,0.95),(0.915,2.625),(0.865,2.625),(0.865,3.095),(1.125,3.095),(1.125,2.755),(3.555,2.755),(3.555,2.91),(3.82,2.91),(3.82,2.52),(4.34,2.52),(4.34,1.355),(3.96,1.355),(3.96,0.895),(3.68,0.895),(3.68,1.155),(3.765,1.155),(3.765,1.515),(4.18,1.515),(4.18,2.36),(3.63,2.36),(3.63,2.595),(1.075,2.595),(1.075,0.76),(0.66,0.76),(0.66,0.685)],
  [(1.775,0.815),(1.775,1.02),(1.705,1.02),(1.705,2.315),(1.885,2.315),(1.885,2.41),(2.145,2.41),(2.145,2.12),(1.865,2.12),(1.865,1.395),(2.835,1.395),(2.835,1.865),(3.19,1.865),(3.19,1.645),(3.01,1.645),(3.01,1.235),(2.145,1.235),(2.145,0.815)])
R(sg13g2_dfrbp_1, Metal1_pin, [(0,-0.22,12.48,0.22), (0.44,1.22,0.735,2.415), (2.045,1.575,2.49,1.915), (9.79,2.08,10.38,3.165), (11.785,2.105,12.145,3.135), (0,3.56,12.48,4)])
P(sg13g2_dfrbp_1, Metal2, [(1.28,1.965),(1.28,2.37),(1.57,2.37),(1.57,2.2),(5.6,2.2),(5.6,2.37),(5.89,2.37),(5.89,2.2),(8.275,2.2),(8.275,2.37),(8.725,2.37),(8.725,2),(1.57,2),(1.57,1.965)])
R(sg13g2_dfrbp_1, Metal2_pin, [(1.28,1.965,1.57,2.37)])
R(sg13g2_dfrbp_1, pSD, [(-0.07,-0.18,12.55,0.18)])
P(sg13g2_dfrbp_1, pSD, [(5.815,1.655),(5.815,2.235),(3.485,2.235),(3.485,1.88),(1.585,1.88),(1.585,1.76),(-0.07,1.76),(-0.07,3.6),(12.55,3.6),(12.55,1.76),(7.745,1.76),(7.745,1.655)])
R(sg13g2_dfrbp_1, Via1, [(1.305,2.015,1.495,2.205), (5.665,2.13,5.855,2.32), (8.44,2.145,8.63,2.335)])
P(sg13g2_dfrbp_1, NWell, [(5.765,1.645),(5.765,1.84),(3.345,1.84),(3.345,1.87),(1.595,1.87),(1.595,1.75),(-0.3,1.75),(-0.3,4.17),(12.78,4.17),(12.78,1.75),(7.755,1.75),(7.755,1.645)])
R(sg13g2_dfrbp_1, boundary, [(0,0,12.48,3.78)])
sg13g2_dfrbp_1.add(gdstk.Label('D', (0.605,1.8), layer=8, texttype=25))
sg13g2_dfrbp_1.add(gdstk.Label('Q_N', (10.08,2.635), layer=8, texttype=25))
sg13g2_dfrbp_1.add(gdstk.Label('CLK', (2.365,1.725), layer=8, texttype=25))
sg13g2_dfrbp_1.add(gdstk.Label('VSS', (5.98,0), layer=8, texttype=25))
sg13g2_dfrbp_1.add(gdstk.Label('VDD', (6.165,3.78), layer=8, texttype=25))
sg13g2_dfrbp_1.add(gdstk.Label('Q', (11.995,2.75), layer=8, texttype=25))
sg13g2_dfrbp_1.add(gdstk.Label('RESET_B', (1.44,2.1), layer=10, texttype=25))

dff_nclk = lib.new_cell('dff_nclk')
R(dff_nclk, Activ, [(-2.49,-0.57,-1.95,-0.27), (-2.49,3.21,-1.95,3.51)])
R(dff_nclk, Metal1, [(-2.49,-0.64,-1.95,-0.2), (-2.655,0.175,-2.265,0.655), (-2.49,3.14,-1.95,3.58)])
R(dff_nclk, Metal2, [(-1.61,0.8,-1.11,1.09), (-3.605,1.09,-3.315,1.59), (7.84,1.71,8.43,2), (9.765,2.375,10.265,2.665)])
P(dff_nclk, Metal2, [(-2.605,0.27),(-2.605,0.56),(0.165,0.56),(0.165,1.37),(0.465,1.37),(0.465,0.27)])
R(dff_nclk, Metal2_pin, [(-1.61,0.8,-1.11,1.09), (-3.605,1.09,-3.315,1.59), (1.215,1.58,1.715,1.78), (7.84,1.71,8.43,2), (9.765,2.375,10.265,2.665)])
R(dff_nclk, pSD, [(-2.42,-0.6,-2.02,-0.24), (-2.42,1.34,-2.02,3.18)])
R(dff_nclk, Via1, [(-2.555,0.32,-2.365,0.51), (-1.455,0.85,-1.265,1.04), (0.225,1.17,0.415,1.36), (-3.555,1.245,-3.365,1.435), (8.04,1.76,8.23,1.95), (9.92,2.425,10.11,2.615)])
dff_nclk.add(gdstk.Reference(sg13g2_inv_1, (-3.93,-0.42)))
dff_nclk.add(gdstk.Reference(sg13g2_dfrbp_1, (-1.95,-0.42)))
dff_nclk.add(gdstk.Label('nRST', (1.465,1.68), layer=10, texttype=25))
dff_nclk.add(gdstk.Label('nCLK', (-3.46,1.34), layer=10, texttype=25))
dff_nclk.add(gdstk.Label('D', (-1.363,0.945), layer=10, texttype=25))
dff_nclk.add(gdstk.Label('nQ', (8.135,1.855), layer=10, texttype=25))
dff_nclk.add(gdstk.Label('Q', (10.015,2.52), layer=10, texttype=25))

freq_div_cell = lib.new_cell('freq_div_cell')
R(freq_div_cell, Activ, [(0.54,-1.94,7.26,-1.46), (11.16,-1.94,15,-1.46), (7.26,2.32,11.16,2.62)])
R(freq_div_cell, Metal1, [(0.54,-1.87,15,-1.53), (7.26,2.25,11.16,2.69)])
P(freq_div_cell, Metal1, [(15,-6.09),(15,-5.65),(15.3,-5.65),(15.3,2.25),(15,2.25),(15,2.69),(15.7,2.69),(15.7,-6.09)])
R(freq_div_cell, Metal2, [(-0.1,-4.36,0.865,-3.86), (-0.1,-0.905,0.54,-0.35), (14.545,-0.44,15.7,0.06), (-0.1,1.51,0.54,2.065)])
P(freq_div_cell, Metal2, [(-0.1,-5.92),(-0.1,-5.42),(0.865,-5.42),(0.865,-5.525),(6.22,-5.525),(6.22,-3.87),(6.51,-3.87),(6.51,-5.815),(0.865,-5.815),(0.865,-5.92)],
  [(1.85,-4.65),(1.85,-1.56),(6.48,-1.56),(6.48,-0.905),(7.26,-0.905),(7.26,-1.96),(2.27,-1.96),(2.27,-4.36),(2.86,-4.36),(2.86,-4.65)],
  [(14.235,-2.785),(14.235,-2),(8.91,-2),(8.91,1.64),(7.26,1.64),(7.26,2.065),(9.31,2.065),(9.31,-1.6),(11.39,-1.6),(11.39,0.96),(11.89,0.96),(11.89,-1.6),(14.735,-1.6),(14.735,-2.785)],
  [(13.115,0.595),(13.115,2.065),(15.7,2.065),(15.7,1.565),(13.615,1.565),(13.615,0.595)])
R(freq_div_cell, Metal2_pin, [(-0.1,-5.92,0.54,-5.42), (-0.1,-4.36,0.54,-3.86), (-0.1,-0.905,0.54,-0.35), (15.06,-0.44,15.7,0.06), (-0.1,1.51,0.54,2.065), (15.06,1.565,15.7,2.065)])
R(freq_div_cell, pSD, [(7.33,2.29,11.09,2.65)])
R(freq_div_cell, Via1, [(14.645,-0.285,14.835,-0.095), (13.27,0.675,13.46,0.865), (11.545,0.695,11.735,0.885)])
freq_div_cell.add(gdstk.Reference(half_add, (4.18,1.6), x_reflection=True))
freq_div_cell.add(gdstk.Reference(sg13g2_xor2_1, (11.16,2.47), x_reflection=True))
freq_div_cell.add(gdstk.Reference(dff_nclk, (4.47,-5.45)))
freq_div_cell.add(gdstk.Label('Cin', (0.22,1.788), layer=10, texttype=25))
freq_div_cell.add(gdstk.Label('Cout', (0.22,-0.628), layer=10, texttype=25))
freq_div_cell.add(gdstk.Label('CLK', (0.22,-4.11), layer=10, texttype=25))
freq_div_cell.add(gdstk.Label('nRST', (0.22,-5.67), layer=10, texttype=25))
freq_div_cell.add(gdstk.Label('BIT', (15.38,1.815), layer=10, texttype=25))
freq_div_cell.add(gdstk.Label('DIV', (15.38,-0.19), layer=10, texttype=25))

sg13g2_tiehi = lib.new_cell('sg13g2_tiehi')
P(sg13g2_tiehi, Activ, [(0.115,2.145),(0.115,2.805),(0.705,2.805),(0.705,3.075),(0.115,3.075),(0.115,3.63),(0,3.63),(0,3.93),(1.92,3.93),(1.92,3.63),(1.02,3.63),(1.02,3.3),(1.58,3.3),(1.58,2.145)],
  [(0,-0.15),(0,0.15),(0.685,0.15),(0.685,0.975),(0.115,0.975),(0.115,1.275),(1.58,1.275),(1.58,0.48),(1.01,0.48),(1.01,0.15),(1.92,0.15),(1.92,-0.15)])
P(sg13g2_tiehi, GatPoly, [(1.33,1.675),(1.33,1.68),(1.325,1.68),(1.325,1.685),(1.32,1.685),(1.32,1.69),(1.315,1.69),(1.315,1.695),(1.31,1.695),(1.31,1.7),(1.305,1.7),(1.305,1.705),(1.3,1.705),(1.3,1.71),(1.295,1.71),(1.295,1.83),(1.11,1.83),(1.11,3.49),(1.24,3.49),(1.24,1.975),(1.595,1.975),(1.595,1.675)],
  [(0.455,0.785),(0.455,1.355),(0.115,1.355),(0.115,1.655),(0.455,1.655),(0.455,2.065),(0.485,2.065),(0.485,2.995),(0.615,2.995),(0.615,1.935),(0.585,1.935),(0.585,0.785)],
  [(1.105,0.3),(1.105,1.345),(0.845,1.345),(0.845,1.645),(1.11,1.645),(1.11,1.64),(1.115,1.64),(1.115,1.635),(1.12,1.635),(1.12,1.63),(1.125,1.63),(1.125,1.625),(1.13,1.625),(1.13,1.62),(1.135,1.62),(1.135,1.615),(1.14,1.615),(1.14,1.61),(1.145,1.61),(1.145,1.49),(1.235,1.49),(1.235,0.3)])
R(sg13g2_tiehi, Cont, [(0.16,-0.08,0.32,0.08), (0.16,-0.08,0.32,0.08), (0.64,-0.08,0.8,0.08), (0.64,-0.08,0.8,0.08), (1.12,-0.08,1.28,0.08), (1.12,-0.08,1.28,0.08), (1.6,-0.08,1.76,0.08), (1.6,-0.08,1.76,0.08), (1.35,1.035,1.51,1.195), (0.185,1.045,0.345,1.205), (0.915,1.415,1.075,1.575), (0.185,1.425,0.345,1.585), (1.365,1.745,1.525,1.905), (1.35,2.215,1.51,2.375), (0.185,2.23,0.345,2.39), (1.35,2.655,1.51,2.815), (0.16,3.7,0.32,3.86), (0.16,3.7,0.32,3.86), (0.64,3.7,0.8,3.86), (0.64,3.7,0.8,3.86), (1.12,3.7,1.28,3.86), (1.12,3.7,1.28,3.86), (1.6,3.7,1.76,3.86), (1.6,3.7,1.76,3.86)])
R(sg13g2_tiehi, Metal1, [(0,-0.22,1.92,0.22), (1.3,0.985,1.575,1.95), (0.135,1.03,0.395,1.635), (1.3,2.13,1.585,2.91), (0,3.56,1.92,4)])
P(sg13g2_tiehi, Metal1, [(0.87,1.355),(0.87,1.815),(0.195,1.815),(0.195,2.19),(0.135,2.19),(0.135,2.45),(0.395,2.45),(0.395,2.03),(1.12,2.03),(1.12,1.355)])
R(sg13g2_tiehi, Metal1_pin, [(0,-0.22,1.92,0.22), (1.3,2.13,1.585,2.91), (0,3.56,1.92,4)])
R(sg13g2_tiehi, pSD, [(-0.07,-0.18,1.99,0.18), (-0.07,1.76,1.99,3.6)])
R(sg13g2_tiehi, NWell, [(-0.24,1.75,2.16,4.17)])
R(sg13g2_tiehi, boundary, [(0,0,1.92,3.78)])
sg13g2_tiehi.add(gdstk.Label('L_HI', (1.443,2.52), layer=8, texttype=25))
sg13g2_tiehi.add(gdstk.Label('VDD', (0.985,3.785), layer=8, texttype=25))
sg13g2_tiehi.add(gdstk.Label('VSS', (0.94,0), layer=8, texttype=25))

sg13g2_or3_1 = lib.new_cell('sg13g2_or3_1')
R(sg13g2_or3_1, Activ, [(0,-0.15,3.36,0.15), (0,3.63,3.36,3.93)])
P(sg13g2_or3_1, Activ, [(0.365,2.06),(0.365,3.06),(2.14,3.06),(2.14,3.18),(2.98,3.18),(2.98,2.06)],
  [(0.365,0.59),(0.365,1.14),(2.265,1.14),(2.265,1.33),(3.045,1.33),(3.045,0.59)])
P(sg13g2_or3_1, GatPoly, [(0.705,0.41),(0.705,1.57),(0.495,1.57),(0.495,1.9),(0.705,1.9),(0.705,3.24),(0.835,3.24),(0.835,0.41)],
  [(1.215,0.41),(1.215,1.57),(1.09,1.57),(1.09,3.24),(1.22,3.24),(1.22,1.9),(1.42,1.9),(1.42,1.57),(1.345,1.57),(1.345,0.41)],
  [(2.065,0.41),(2.065,1.57),(1.66,1.57),(1.66,3.24),(1.79,3.24),(1.79,1.9),(2.195,1.9),(2.195,0.41)],
  [(2.575,0.41),(2.575,1.535),(2.395,1.535),(2.395,1.835),(2.51,1.835),(2.51,3.36),(2.64,3.36),(2.64,1.835),(2.705,1.835),(2.705,0.41)])
R(sg13g2_or3_1, Cont, [(0.16,-0.08,0.32,0.08), (0.16,-0.08,0.32,0.08), (0.64,-0.08,0.8,0.08), (0.64,-0.08,0.8,0.08), (1.12,-0.08,1.28,0.08), (1.12,-0.08,1.28,0.08), (1.6,-0.08,1.76,0.08), (1.6,-0.08,1.76,0.08), (2.08,-0.08,2.24,0.08), (2.08,-0.08,2.24,0.08), (2.56,-0.08,2.72,0.08), (2.56,-0.08,2.72,0.08), (3.04,-0.08,3.2,0.08), (3.04,-0.08,3.2,0.08), (2.815,0.665,2.975,0.825), (0.945,0.72,1.105,0.88), (2.305,0.72,2.465,0.88), (1.455,0.76,1.615,0.92), (1.795,0.76,1.955,0.92), (0.435,0.785,0.595,0.945), (2.815,1.095,2.975,1.255), (2.465,1.605,2.625,1.765), (0.58,1.655,0.74,1.815), (1.175,1.655,1.335,1.815), (1.825,1.655,1.985,1.815), (2.75,2.14,2.91,2.3), (0.435,2.255,0.595,2.415), (1.9,2.49,2.06,2.65), (2.24,2.49,2.4,2.65), (2.75,2.54,2.91,2.7), (0.435,2.825,0.595,2.985), (1.9,2.83,2.06,2.99), (2.24,2.83,2.4,2.99), (2.75,2.945,2.91,3.105), (0.16,3.7,0.32,3.86), (0.16,3.7,0.32,3.86), (0.64,3.7,0.8,3.86), (0.64,3.7,0.8,3.86), (1.12,3.7,1.28,3.86), (1.12,3.7,1.28,3.86), (1.6,3.7,1.76,3.86), (1.6,3.7,1.76,3.86), (2.08,3.7,2.24,3.86), (2.08,3.7,2.24,3.86), (2.56,3.7,2.72,3.86), (2.56,3.7,2.72,3.86), (3.04,3.7,3.2,3.86), (3.04,3.7,3.2,3.86)])
R(sg13g2_or3_1, Metal1, [(0.295,1.505,0.835,1.935), (1.09,1.505,1.56,1.935), (1.74,1.505,2.07,1.935)])
P(sg13g2_or3_1, Metal1, [(2.76,0.605),(2.76,1.305),(2.89,1.305),(2.89,2.04),(2.7,2.04),(2.7,3.2),(3.05,3.2),(3.05,0.605)],
  [(1.445,0.675),(1.445,1.11),(0.645,1.11),(0.645,0.765),(0.385,0.765),(0.385,1.325),(2.345,1.325),(2.345,2.12),(0.385,2.12),(0.385,2.995),(0.645,2.995),(0.645,2.295),(2.515,2.295),(2.515,1.85),(2.71,1.85),(2.71,1.52),(2.515,1.52),(2.515,1.115),(1.965,1.115),(1.965,0.675)],
  [(1.85,2.475),(1.85,3.56),(0,3.56),(0,4),(3.36,4),(3.36,3.56),(2.45,3.56),(2.45,2.475)],
  [(0,-0.22),(0,0.22),(0.895,0.22),(0.895,0.89),(1.155,0.89),(1.155,0.22),(2.255,0.22),(2.255,0.89),(2.515,0.89),(2.515,0.22),(3.36,0.22),(3.36,-0.22)])
R(sg13g2_or3_1, Metal1_pin, [(0,-0.22,3.36,0.22), (0.295,1.505,0.835,1.935), (1.09,1.505,1.56,1.935), (1.74,1.505,2.07,1.935), (2.7,2.04,3.05,3.2), (0,3.56,3.36,4)])
R(sg13g2_or3_1, pSD, [(-0.07,-0.18,3.43,0.18), (-0.07,1.76,3.43,3.6)])
R(sg13g2_or3_1, NWell, [(-0.24,1.75,3.6,4.17)])
R(sg13g2_or3_1, boundary, [(0,0,3.36,3.78)])
sg13g2_or3_1.add(gdstk.Label('C', (0.565,1.735), layer=8, texttype=25))
sg13g2_or3_1.add(gdstk.Label('A', (1.91,1.725), layer=8, texttype=25))
sg13g2_or3_1.add(gdstk.Label('VDD', (1.655,3.79), layer=8, texttype=25))
sg13g2_or3_1.add(gdstk.Label('VSS', (1.69,0.005), layer=8, texttype=25))
sg13g2_or3_1.add(gdstk.Label('B', (1.335,1.695), layer=8, texttype=25))
sg13g2_or3_1.add(gdstk.Label('X', (2.865,2.77), layer=8, texttype=25))

sg13g2_nand2_1 = lib.new_cell('sg13g2_nand2_1')
R(sg13g2_nand2_1, Activ, [(0,-0.15,1.92,0.15), (0.375,0.59,1.495,1.33), (0.3,2.06,1.62,3.18), (0,3.63,1.92,3.93)])
P(sg13g2_nand2_1, GatPoly, [(0.715,0.41),(0.715,1.44),(0.33,1.44),(0.33,1.77),(0.64,1.77),(0.64,3.36),(0.77,3.36),(0.77,1.77),(0.845,1.77),(0.845,0.41)],
  [(1.025,0.41),(1.025,1.77),(1.15,1.77),(1.15,3.36),(1.28,3.36),(1.28,1.77),(1.56,1.77),(1.56,1.44),(1.155,1.44),(1.155,0.41)])
A(sg13g2_nand2_1, Cont, 0.37, 2.14, 0.16, 0.16, 3, 2, 0.51, 0.4)
A(sg13g2_nand2_1, Cont, 0.37, 2.95, 0.16, 0.16, 3, 1, 0.51, 0)
R(sg13g2_nand2_1, Cont, [(0.16,-0.08,0.32,0.08), (0.16,-0.08,0.32,0.08), (0.64,-0.08,0.8,0.08), (0.64,-0.08,0.8,0.08), (1.12,-0.08,1.28,0.08), (1.12,-0.08,1.28,0.08), (1.6,-0.08,1.76,0.08), (1.6,-0.08,1.76,0.08), (0.445,0.67,0.605,0.83), (1.265,0.67,1.425,0.83), (0.445,1.065,0.605,1.225), (1.265,1.065,1.425,1.225), (1.33,1.51,1.49,1.67), (0.4,1.525,0.56,1.685), (0.16,3.7,0.32,3.86), (0.16,3.7,0.32,3.86), (0.64,3.7,0.8,3.86), (0.64,3.7,0.8,3.86), (1.12,3.7,1.28,3.86), (1.12,3.7,1.28,3.86), (1.6,3.7,1.76,3.86), (1.6,3.7,1.76,3.86)])
R(sg13g2_nand2_1, Metal1, [(0.29,1.44,0.62,1.81), (1.27,1.44,1.6,1.81)])
P(sg13g2_nand2_1, Metal1, [(0.32,2.125),(0.32,3.56),(0,3.56),(0,4),(1.92,4),(1.92,3.56),(1.6,3.56),(1.6,2.125),(1.34,2.125),(1.34,3.56),(0.58,3.56),(0.58,2.125)],
  [(0,-0.22),(0,0.22),(0.395,0.22),(0.395,1.245),(0.655,1.245),(0.655,0.22),(1.92,0.22),(1.92,-0.22)],
  [(1.215,0.655),(1.215,1.06),(0.86,1.06),(0.86,1.365),(0.83,1.365),(0.83,3.125),(1.09,3.125),(1.09,1.245),(1.475,1.245),(1.475,0.655)])
R(sg13g2_nand2_1, Metal1_pin, [(0,-0.22,1.92,0.22), (0.83,1.365,1.09,3.125), (0.29,1.44,0.62,1.81), (1.27,1.44,1.6,1.81), (0,3.56,1.92,4)])
R(sg13g2_nand2_1, pSD, [(-0.07,-0.18,1.99,0.18), (-0.07,1.76,1.99,3.6)])
R(sg13g2_nand2_1, NWell, [(-0.24,1.75,2.16,4.17)])
R(sg13g2_nand2_1, boundary, [(0,0,1.92,3.78)])
sg13g2_nand2_1.add(gdstk.Label('Y', (0.97,2.21), layer=8, texttype=25))
sg13g2_nand2_1.add(gdstk.Label('VDD', (0.97,3.78), layer=8, texttype=25))
sg13g2_nand2_1.add(gdstk.Label('A', (1.435,1.63), layer=8, texttype=25))
sg13g2_nand2_1.add(gdstk.Label('VSS', (0.99,0), layer=8, texttype=25))
sg13g2_nand2_1.add(gdstk.Label('B', (0.45,1.62), layer=8, texttype=25))

c_3bit_freq_divider = lib.new_cell('3bit_freq_divider')
R(c_3bit_freq_divider, Activ, [(15.59,-13.47,15.89,-12.99), (19.37,-13.47,19.67,-12.99), (-1.16,-12.65,13.3,-12.51), (-1.16,-3.87,13.3,-3.73), (-2.04,0.83,-1.16,1.13), (15.59,1.47,15.89,2.01), (19.37,1.47,19.67,2.01), (-2.04,4.61,-1.16,4.91)])
R(c_3bit_freq_divider, Metal1, [(19.3,-13.47,19.74,-12.99), (-2.485,-13.08,-2.04,0.76), (-2.04,0.76,-1.16,1.2), (19.3,1.47,19.74,2.01), (-2.04,4.54,-1.16,4.98)])
P(c_3bit_freq_divider, Metal1, [(-4.7,0.76),(-4.7,5.68),(19.74,5.68),(19.74,3.93),(19.3,3.93),(19.3,5.28),(-4.3,5.28),(-4.3,1.2),(-3.96,1.2),(-3.96,0.76)],
  [(-2.375,1.85),(-2.375,2.63),(-1.71,2.63),(-1.71,4.355),(-1.055,4.355),(-1.055,3.8),(-1.36,3.8),(-1.36,1.85)],
  [(14,-16.83),(14,3.93),(15.52,3.93),(15.52,2.01),(15.96,2.01),(15.96,1.47),(15.52,1.47),(15.52,-12.99),(15.96,-12.99),(15.96,-13.47),(15.52,-13.47),(15.52,-16.83)],
  [(-1.71,-19.62),(-1.71,-16.425),(-2.485,-16.425),(-2.485,-15.835),(-1.71,-15.835),(-1.71,-1.58),(-1.035,-1.58),(-1.035,-2.06),(-1.36,-2.06),(-1.36,-10.36),(-1.035,-10.36),(-1.035,-10.84),(-1.36,-10.84),(-1.36,-19.14),(-1.035,-19.14),(-1.035,-19.62)],
  [(-3.96,-22.06),(-3.96,-21.66),(-2.485,-21.66),(-2.485,-17.3),(-2.04,-17.3),(-2.04,-20.92),(-1.16,-20.92),(-1.16,-21.36),(14,-21.36),(14,-21.66),(19.74,-21.66),(19.74,-22.06)])
A(c_3bit_freq_divider, Metal2, 6.06, -17.55, 0.4, 0.72, 1, 3, 0, 8.78)
A(c_3bit_freq_divider, Metal2, -0.985, -17.535, 0.4, 1.13, 1, 3, 0, 8.78)
R(c_3bit_freq_divider, Metal2, [(-3.96,-22.06,19.74,-21.66), (14,-15.54,17.625,-15.21), (13.5,-13.205,14,-12.29), (14,-4.925,14.915,-4.425), (18.825,0.705,20.485,1.205), (14,3.855,14.915,4.355), (-3.96,5.28,19.74,5.68)])
P(c_3bit_freq_divider, Metal2, [(-2.43,-4.98),(-2.43,1.94),(-1.8,1.94),(-1.8,1.385),(-2.03,1.385),(-2.03,-4.425),(-1.8,-4.425),(-1.8,-4.98)],
  [(-2.43,-13.76),(-2.43,-6.84),(-1.8,-6.84),(-1.8,-7.395),(-2.03,-7.395),(-2.03,-13.205),(-1.8,-13.205),(-1.8,-13.76)],
  [(-4.7,-19.75),(-4.7,-19.25),(-3.655,-19.25),(-3.655,-15.305),(-3.355,-15.305),(-3.355,-19.75)],
  [(-2.675,-15.61),(-2.675,-14.72),(-4.7,-14.72),(-4.7,-14.22),(-2.375,-14.22),(-2.375,-15.61)],
  [(17.25,-10.67),(17.25,-10.17),(18.61,-10.17),(18.61,-1.22),(18.16,-1.22),(18.16,-0.63),(19.06,-0.63),(19.06,-10.67)],
  [(16.43,-2.735),(16.43,2.715),(18.455,2.715),(18.455,2.265),(16.72,2.265),(16.72,-2.285),(17.74,-2.285),(17.74,-2.735)],
  [(15.47,-14.2),(15.47,1.85),(14,1.85),(14,2.35),(15.92,2.35),(15.92,-13.87),(17.625,-13.87),(17.625,-14.2)],
  [(9.095,-20.195),(9.095,-19.14),(9.545,-19.14),(9.545,-19.745),(13.55,-19.745),(13.55,-16.495),(10.58,-16.495),(10.58,-13.18),(9.095,-13.18),(9.095,-10.36),(9.545,-10.36),(9.545,-10.965),(13.55,-10.965),(13.55,-7.715),(10.58,-7.715),(10.58,-4.4),(9.095,-4.4),(9.095,-1.58),(9.545,-1.58),(9.545,-3.95),(11.03,-3.95),(11.03,-7.265),(14,-7.265),(14,-11.415),(9.545,-11.415),(9.545,-12.73),(11.03,-12.73),(11.03,-16.045),(14,-16.045),(14,-16.12),(18.105,-16.12),(18.105,-12.665),(17.75,-12.665),(17.75,-12.375),(18.555,-12.375),(18.555,-16.57),(14,-16.57),(14,-20.195)],
  [(14.51,-14.96),(14.51,-6.93),(14,-6.93),(14,-6.43),(14.96,-6.43),(14.96,-14.63),(17.625,-14.63),(17.625,-14.96)])
R(c_3bit_freq_divider, Metal2_pin, [(-3.96,-22.06,19.74,-21.66), (-3.96,5.28,19.74,5.68)])
R(c_3bit_freq_divider, pSD, [(15.56,-13.4,15.92,-13.06), (17.5,-13.4,19.34,-13.06), (-1.23,-12.62,13.37,-12.54), (-1.23,-3.84,13.37,-3.76), (-1.97,1.16,-1.23,3), (15.56,1.54,15.92,1.94), (17.5,1.54,19.34,1.94), (-1.97,4.58,-1.23,4.94)])
A(c_3bit_freq_divider, Via1, -3.705, -21.955, 0.19, 0.19, 47, 2, 0.5, 27.34)
A(c_3bit_freq_divider, Via1, -0.88, -17.475, 0.19, 0.19, 1, 3, 0, 0.41)
A(c_3bit_freq_divider, Via1, -0.88, -8.695, 0.19, 0.19, 1, 3, 0, 0.41)
A(c_3bit_freq_divider, Via1, -0.88, 0.085, 0.19, 0.19, 1, 3, 0, 0.41)
R(c_3bit_freq_divider, Via1, [(6.165,-17.49,6.355,-17.3), (6.165,-17.08,6.355,-16.89), (18.265,-16.44,18.455,-16.25), (-3.6,-15.555,-3.41,-15.365), (-2.62,-15.555,-2.43,-15.365), (17.365,-15.47,17.555,-15.28), (17.365,-14.89,17.555,-14.7), (17.365,-14.13,17.555,-13.94), (6.165,-8.71,6.355,-8.52), (6.165,-8.3,6.355,-8.11), (6.165,0.07,6.355,0.26), (6.165,0.48,6.355,0.67), (18.165,2.395,18.355,2.585)])
A(c_3bit_freq_divider, Via2, -0.88, -17.475, 0.19, 0.19, 1, 3, 0, 0.41)
A(c_3bit_freq_divider, Via2, -0.88, -8.695, 0.19, 0.19, 1, 3, 0, 0.41)
A(c_3bit_freq_divider, Via2, -0.88, 0.085, 0.19, 0.19, 1, 3, 0, 0.41)
R(c_3bit_freq_divider, Via2, [(-4.335,-19.595,-4.145,-19.405), (6.165,-17.49,6.355,-17.3), (6.165,-17.08,6.355,-16.89), (-4.335,-14.565,-4.145,-14.375), (13.655,-12.845,13.845,-12.655), (6.165,-8.71,6.355,-8.52), (6.165,-8.3,6.355,-8.11), (14.36,-4.77,14.55,-4.58), (6.165,0.07,6.355,0.26), (6.165,0.48,6.355,0.67), (19.93,0.86,20.12,1.05), (14.36,4.01,14.55,4.2)])
R(c_3bit_freq_divider, Metal3, [(-4.7,-19.75,-3.785,-19.25), (6.06,-17.55,6.46,0.73), (-0.985,-17.535,-0.585,1.155), (-4.7,-14.72,-3.785,-14.22), (13.5,-13.205,14,-12.29), (14,-4.925,14.915,-4.425), (19.57,0.705,20.485,1.205), (14,3.855,14.915,4.355)])
R(c_3bit_freq_divider, Metal3_pin, [(-4.7,-19.75,-3.785,-19.25), (-4.7,-14.72,-3.785,-14.22), (13.5,-13.205,14,-12.29), (14,-4.925,14.915,-4.425), (19.57,0.705,20.485,1.205), (14,3.855,14.915,4.355)])
R(c_3bit_freq_divider, NWell, [(-1.8,0.59,-1.4,3.01)])
R(c_3bit_freq_divider, boundary, [(-5,-22.06,20.783,5.68)])
c_3bit_freq_divider.add(gdstk.Reference(freq_div_cell, (-1.7,2.29)))
c_3bit_freq_divider.add(gdstk.Reference(freq_div_cell, (-1.7,-15.27)))
c_3bit_freq_divider.add(gdstk.Reference(freq_div_cell, (-1.7,-6.49)))
c_3bit_freq_divider.add(gdstk.Reference(sg13g2_tiehi, (-3.96,4.76), x_reflection=True))
c_3bit_freq_divider.add(gdstk.Reference(sg13g2_tiehi, (15.74,3.93), rotation=3*pi/2))
c_3bit_freq_divider.add(gdstk.Reference(sg13g2_or3_1, (15.74,-13.47), rotation=3*pi/2))
c_3bit_freq_divider.add(gdstk.Reference(dff_nclk, (16.16,-9.06), rotation=pi/2, x_reflection=True))
c_3bit_freq_divider.add(gdstk.Reference(sg13g2_nand2_1, (-3.96,-17.08)))
c_3bit_freq_divider.add(gdstk.Label('VSS', (7.89,-21.86), layer=10, texttype=25))
c_3bit_freq_divider.add(gdstk.Label('VDD', (7.89,5.48), layer=10, texttype=25))
c_3bit_freq_divider.add(gdstk.Label('CLK_OUT', (20.02,0.955), layer=30, texttype=25))
c_3bit_freq_divider.add(gdstk.Label('A0', (14.45,4.105), layer=30, texttype=25))
c_3bit_freq_divider.add(gdstk.Label('A1', (14.45,-4.675), layer=30, texttype=25))
c_3bit_freq_divider.add(gdstk.Label('A2', (13.75,-12.755), layer=30, texttype=25))
c_3bit_freq_divider.add(gdstk.Label('EN', (-4.25,-19.5), layer=30, texttype=25))
c_3bit_freq_divider.add(gdstk.Label('CLK_IN', (-4.255,-14.47), layer=30, texttype=25))

lib.write_gds('3bit_freq_divider.gds')
